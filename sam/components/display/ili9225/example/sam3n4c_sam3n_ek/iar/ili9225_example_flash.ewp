# IAR project ili9225_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../../../drivers/uart; ../../../../../../../common/services/spi/sam_spi; ../../../../../../utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/services/spi; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../utils/cmsis/sam3n/source/templates; ../../..; ../../../../../../drivers/pmc; ../../../../../../drivers/pio; ../../../../../../drivers/spi; ../../../../../../utils/cmsis/sam3n/include; ../../../../../../../common/utils; ../../../../../../boards/sam3n_ek; ..; ../../../../../../../common/services/gpio; ../../../../aat31xx; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  OBJCOPY.OOCOutputFile: ili9225_example_flash.bin
  ILINK.IlinkOutputFile: ili9225_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/spi
    ../../../../../../drivers/spi/: spi.c
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: pmc.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/syscalls/iar
    ../../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/components/display/ili9225
    ../../../: ili9225.c
  group sam/components/display/ili9225/example
    ../../: ili9225_example.c
  group sam/components/display/aat31xx
    ../../../../aat31xx/: aat31xx.c
  group sam/boards/sam3n_ek
    ../../../../../../boards/sam3n_ek/: init.c
  group common/services/clock/sam3n
    ../../../../../../../common/services/clock/sam3n/: sysclk.c
  group common/services/spi/sam_spi
    ../../../../../../../common/services/spi/sam_spi/: spi_master.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
