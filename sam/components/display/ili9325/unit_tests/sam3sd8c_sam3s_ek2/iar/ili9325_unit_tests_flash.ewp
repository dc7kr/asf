# IAR project ili9325_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3SD8C__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../../../boards/sam3s_ek2; ../../../../../../drivers/ebi/smc; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../../common/services/clock; ../../../../../../utils/cmsis/sam3s8/source/templates; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../..; ..; ../..; ../../../../../../drivers/pmc; ../../../../../../drivers/pio; ../../../../../../utils/cmsis/sam3s8/include; ../../../../../../boards; ../../../../../../../common/utils; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/services/gpio; ../../../../../../../common/services/serial; ../../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: ili9325_unit_tests_flash.bin
  ILINK.IlinkOutputFile: ili9325_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: pmc.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/components/display/ili9325
    ../../../: ili9325.c
  group sam/components/display/ili9325/unit_tests
    ../../: unit_tests.c
  group sam/boards/sam3s_ek2
    ../../../../../../boards/sam3s_ek2/: init.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3s
    ../../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c
