# IAR project sam_components_display_ili9325_unit_tests_sam4s_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM4S_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/sam4s/source/templates; ../../../../../../drivers/ebi/smc; ../../../../../../drivers/uart; ..; ../../../../../../utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../..; ../..; ../../../../../../drivers/pmc; ../../../../../../drivers/pio; ../../../../../../boards/sam4s_ek; ../../../../../../../common/utils; ../../../../../../utils/cmsis/sam4s/include; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/services/gpio; ../../../../../../../common/services/serial; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_components_display_ili9325_unit_tests_sam4s_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/syscalls/iar
    ../../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/components/display/ili9325
    ../../../: ili9325.c
  group sam/components/display/ili9325/unit_tests
    ../../: unit_tests.c
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: pmc.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/boards/sam4s_ek
    ../../../../../../boards/sam4s_ek/: init.c
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c
