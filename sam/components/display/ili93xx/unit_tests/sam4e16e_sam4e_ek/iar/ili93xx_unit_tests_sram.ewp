# IAR project ili93xx_unit_tests_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../..; ../../../../../../utils/preprocessor; ../../../../../../drivers/pmc; ../../..; ../../../../../../drivers/ebi/smc; ../../../../../../utils/fpu; ../../../../../../../common/services/serial; ../../../../../../utils/cmsis/sam4e/source/templates; ..; ../../../../../../../common/utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../aat31xx; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../utils/cmsis/sam4e/include; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../drivers/pio; ../../../../../../boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ili93xx_unit_tests_sram.bin
  ILINK.IlinkOutputFile: ili93xx_unit_tests_sram.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4e/sam4e16e/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/components/display/ili93xx
    ../../../: ili93xx.c
  group sam/components/display/ili93xx/unit_tests
    ../../: unit_tests.c
  group sam/components/display/aat31xx
    ../../../../aat31xx/: aat31xx.c
  group sam/boards/sam4e_ek
    ../../../../../../boards/sam4e_ek/: init.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4e
    ../../../../../../../common/services/clock/sam4e/: sysclk.c
