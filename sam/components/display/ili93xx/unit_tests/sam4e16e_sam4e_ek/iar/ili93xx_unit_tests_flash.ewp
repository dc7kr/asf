# IAR project ili93xx_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../..; ../../../../../../utils/preprocessor; ../../../../../../drivers/pmc; ../../..; ../../../../../../drivers/ebi/smc; ../../../../../../utils/fpu; ../../../../../../../common/services/serial; ../../../../../../utils/cmsis/sam4e/source/templates; ..; ../../../../../../../common/utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../aat31xx; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../utils/cmsis/sam4e/include; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../drivers/pio; ../../../../../../boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ili93xx_unit_tests_flash.bin
  ILINK.IlinkOutputFile: ili93xx_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../utils/cmsis/sam4e/include/: sam4e16e.h sam4e8e.h sam4e8c.h sam4e16c.h sam4e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../utils/cmsis/sam4e/include/component/: rswdt.h cmcc.h rtc.h can.h aes.h dmac.h twi.h efc.h rstc.h rtt.h chipid.h spi.h pdc.h supc.h pio.h udp.h wdt.h tc.h afec.h gmac.h crccu.h dacc.h matrix.h pwm.h hsmci.h acc.h usart.h pmc.h gpbr.h uart.h smc.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../utils/cmsis/sam4e/include/instance/: piod.h piob.h gmac.h can0.h chipid.h spi.h dacc.h gpbr.h afec0.h cmcc.h udp.h pmc.h supc.h pioe.h usart1.h rtc.h pioc.h afec1.h smc.h tc2.h can1.h twi0.h matrix.h tc1.h dmac.h uart0.h wdt.h pioa.h rswdt.h usart0.h crccu.h tc0.h rtt.h twi1.h aes.h uart1.h efc.h hsmci.h rstc.h pwm.h acc.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../utils/cmsis/sam4e/include/pio/: sam4e8e.h sam4e8c.h sam4e16c.h sam4e16e.h
  group sam/utils/fpu
    ../../../../../../utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c uart.h
  group sam/components/display/ili93xx
    ../../../: ili93xx.c ili9325_regs.h ili9341_regs.h ili93xx.h
  group sam/components/display/ili93xx/unit_tests
    ../../: unit_tests.c
  group sam/components/display/ili93xx/unit_tests/sam4e16e_sam4e_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_aat31xx.h conf_test.h conf_ili93xx.h
  group sam/components/display/ili93xx/unit_tests/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group sam/components/display/aat31xx
    ../../../../aat31xx/: aat31xx.c aat31xx.h
  group sam/boards/sam4e_ek
    ../../../../../../boards/sam4e_ek/: init.c led.h sam4e_ek.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../../../common/services/clock/sam4e/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
