# IAR project hx8347a_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../drivers/ebi/smc; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../../common/services/clock; ../../../../../../../common/services/gpio; ../../../../aat31xx; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../utils/cmsis/sam3x/include; ../../../../../../drivers/pmc; ../../../../../../drivers/pio; ../../..; ../../../../../../boards/sam3x_ek; ../../../../../../boards; ../../../../../../../common/utils; ../..; ..; ../../../../../../utils/cmsis/sam3x/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  OBJCOPY.OOCOutputFile: hx8347a_example_flash.bin
  ILINK.IlinkOutputFile: hx8347a_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/syscalls/iar
    ../../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: pmc.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/boards/sam3x_ek
    ../../../../../../boards/sam3x_ek/: init.c
  group sam/components/display/hx8347a
    ../../../: hx8347a.c
  group sam/components/display/hx8347a/example
    ../../: hx8347a_example.c
  group sam/components/display/aat31xx
    ../../../../aat31xx/: aat31xx.c
  group common/services/clock/sam3x
    ../../../../../../../common/services/clock/sam3x/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
