<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_components_display_hx8347a_example_sam3x_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_components_display_hx8347a_example_sam3x_ek_sram.ewp</path>
	</project>
</workspace>
