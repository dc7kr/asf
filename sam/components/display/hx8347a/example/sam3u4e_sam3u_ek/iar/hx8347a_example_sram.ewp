# IAR project hx8347a_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../drivers/ebi/smc; ../../../../../../drivers/uart; ../../../../../../utils/cmsis/sam3u/source/templates; ../../../../../../utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../aat31xx; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../boards/sam3u_ek; ../../../../../../utils/cmsis/sam3u/include; ../../../../../../drivers/pmc; ../../../../../../drivers/pio; ../../..; ..; ../../../../../../../common/utils; ../..; ../../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; BOARD=SAM3U_EK
  OBJCOPY.OOCOutputFile: hx8347a_example_sram.bin
  ILINK.IlinkOutputFile: hx8347a_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3u/sam3u4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: pmc.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/syscalls/iar
    ../../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam3u_ek
    ../../../../../../boards/sam3u_ek/: init.c
  group sam/components/display/hx8347a
    ../../../: hx8347a.c
  group sam/components/display/hx8347a/example
    ../../: hx8347a_example.c
  group sam/components/display/aat31xx
    ../../../../aat31xx/: aat31xx.c
  group common/services/clock/sam3u
    ../../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
