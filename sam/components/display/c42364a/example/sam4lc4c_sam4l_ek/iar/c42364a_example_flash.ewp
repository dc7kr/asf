# IAR project c42364a_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../..; ../../../../../../../common/services/serial/sam_uart; ../../../../../../drivers/lcdca; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../drivers/pdca; ../../../../../../utils/cmsis/sam4l/include; ../../../../../../utils/cmsis/sam4l/source/templates; ../../../../../../../common/services/serial; ..; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../../boards/sam4l_ek; ../../../../../../drivers/wdt; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/services/delay; ../../../../../../utils; ../../..; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../drivers/flashcalw; ../../../../../../../common/services/ioport; ../../../../../../drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: c42364a_example_flash.bin
  ILINK.IlinkOutputFile: c42364a_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/components/display/c42364a
    ../../../: c42364a.c c42364a.h
  group sam/components/display/c42364a/example
    ../../: c42364a_example.c
  group sam/components/display/c42364a/example/sam4lc4c_sam4l_ek
    ../: conf_uart_serial.h conf_board.h conf_clock.h conf_lcdca.h conf_sleepmgr.h conf_c42364a.h
  group sam/components/display/c42364a/example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group sam/drivers/bpm
    ../../../../../../drivers/bpm/: bpm.c bpm.h
  group sam/drivers/flashcalw
    ../../../../../../drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/lcdca
    ../../../../../../drivers/lcdca/: lcdca.c lcdca.h
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pdca
    ../../../../../../drivers/pdca/: pdca.c pdca.h
  group sam/drivers/wdt
    ../../../../../../drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../utils/cmsis/sam4l/include/: sam4lc2c.h sam4lc4a.h sam4ls4b.h sam4lc2a.h sam4lc4c.h sam4ls8b.h sam4ls2b.h sam4lc2b.h sam4lc4b.h sam4l.h sam4lc8a.h sam4lc8c.h sam4ls4c.h sam4ls8a.h sam4ls4a.h sam4ls2a.h sam4lc8b.h sam4ls8c.h sam4ls2c.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../utils/cmsis/sam4l/include/instance/: instance_tc0.h instance_pdca.h instance_pm.h instance_eic.h instance_catb.h instance_chipid.h instance_usart3.h instance_usart1.h instance_lcdca.h instance_smap.h instance_bpm.h instance_dacc.h instance_gpio.h instance_tc1.h instance_aesa.h instance_adcife.h instance_wdt.h instance_parc.h instance_twim1.h instance_twim0.h instance_hmatrix.h instance_usbc.h instance_twis1.h instance_iisc.h instance_abdacb.h instance_crccu.h instance_twim2.h instance_pevc.h instance_twim3.h instance_trng.h instance_acifc.h instance_ast.h instance_scif.h instance_bscif.h instance_twis0.h instance_hcache.h instance_gloc.h instance_freqm.h instance_usart2.h instance_usart0.h instance_spi.h instance_hflashc.h instance_picouart.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../utils/cmsis/sam4l/include/component/: component_pdca.h component_chipid.h component_abdacb.h component_wdt.h component_flashcalw.h component_adcife.h component_aesa.h component_pm.h component_bscif.h component_scif.h component_lcdca.h component_acifc.h component_spi.h component_eic.h component_crccu.h component_twim.h component_picouart.h component_parc.h component_usbc.h component_gloc.h component_tc.h component_hmatrixb.h component_bpm.h component_freqm.h component_gpio.h component_smap.h component_twis.h component_iisc.h component_hcache.h component_dacc.h component_pevc.h component_catb.h component_usart.h component_ast.h component_trng.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../utils/cmsis/sam4l/include/pio/: pio_sam4lc4b.h pio_sam4lc8c.h pio_sam4lc8b.h pio_sam4lc2c.h pio_sam4lc2a.h pio_sam4ls8a.h pio_sam4ls2b.h pio_sam4ls8c.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4lc4c.h pio_sam4ls2a.h pio_sam4lc2b.h pio_sam4lc8a.h pio_sam4lc4a.h pio_sam4ls8b.h pio_sam4ls4c.h pio_sam4ls4b.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam/boards/sam4l_ek
    ../../../../../../boards/sam4l_ek/: board_monitor.c init.c board_monitor.h sam4l_ek.h led.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h dfll.h pll.h
  group common/services/clock/sam4l
    ../../../../../../../common/services/clock/sam4l/: osc.c pll.c sysclk.c dfll.c genclk.h osc.h pll.h sysclk.h dfll.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
