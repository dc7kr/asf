# IAR project mma7341l_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3U4E__; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../drivers/adc; ../../../../../../../common/services/serial/sam_uart; ../../../../../../utils/cmsis/sam3u/source/templates; ..; ../../../../../../utils/preprocessor; ../../../../../../drivers/pmc; ../..; ../../../../../../../common/services/serial; ../../../../../../../common/utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../boards/sam3u_ek; ../../../../../../utils/cmsis/sam3u/include; ../../../../../../../common/services/gpio; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../drivers/usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../../common/services/ioport; ../../../../../../drivers/pio; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mma7341l_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mma7341l_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c
  group sam/drivers/adc
    ../../../../../../drivers/adc/: adc_sam3u.c adc.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/boards/sam3u_ek
    ../../../../../../boards/sam3u_ek/: led.c init.c
  group sam/components/sensor/mma7341l
    ../../../: mma7341l.c
  group sam/components/sensor/mma7341l/unit_tests
    ../../: unit_tests.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3u
    ../../../../../../../common/services/clock/sam3u/: sysclk.c
