<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ads7843_example_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\ads7843_example_sram.ewp</path>
	</project>
</workspace>
