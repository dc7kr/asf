# IAR project ads7843_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../../../../common/services/spi/sam_spi; ../..; ../../../../../../drivers/pio; ../../../..; ../../../../../../drivers/ebi/smc; ../../../../../../utils/cmsis/sam3s/include; ../../../../../../drivers/spi; ../../../../../../../common/utils; ../../../../../../utils/cmsis/sam3s/source/templates; ../../..; ../../../../../../boards/sam3s_ek; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../display/aat31xx; ..; ../../../../../../utils/preprocessor; ../../../../../../../common/services/gpio; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../../common/services/spi; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../display/ili9325; ../../../../../../drivers/pmc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK
  OBJCOPY.OOCOutputFile: ads7843_example_flash.bin
  ILINK.IlinkOutputFile: ads7843_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/components/resistive_touch
    ../../../../: rtouch.c
  group sam/components/resistive_touch/ads7843
    ../../../: ads7843.c
  group sam/components/resistive_touch/ads7843/example
    ../../: ads7843_example.c rtouch_calibrate.c
  group sam/components/display/ili9325
    ../../../../../display/ili9325/: ili9325.c
  group sam/components/display/aat31xx
    ../../../../../display/aat31xx/: aat31xx.c
  group sam/drivers/pio
    ../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: pmc.c
  group sam/drivers/spi
    ../../../../../../drivers/spi/: spi.c
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c
  group sam/utils/syscalls/iar
    ../../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/boards/sam3s_ek
    ../../../../../../boards/sam3s_ek/: init.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3s
    ../../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/spi/sam_spi
    ../../../../../../../common/services/spi/sam_spi/: spi_master.c
