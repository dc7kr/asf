<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_components_resistive_touch_ads7843_example_sam3s_ek2_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_components_resistive_touch_ads7843_example_sam3s_ek2_sram.ewp</path>
	</project>
</workspace>
