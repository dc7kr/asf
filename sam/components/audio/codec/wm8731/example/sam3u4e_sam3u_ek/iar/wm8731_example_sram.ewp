# IAR project wm8731_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../utils/cmsis/sam3u/source/templates; ../../../../../../../utils/preprocessor; ../..; ../../../../../../../drivers/pmc; ..; ../../../../../../../../common/services/gpio; ../../../../../../../../common/services/serial; ../../../../../../../../common/utils; ../../../../../../../../common/services/clock; ../../../../../../../boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../boards/sam3u_ek; ../../../../../../../drivers/dmac; ../../../../../../../utils/cmsis/sam3u/include; ../../../../../../../drivers/ebi/smc; ../../../../../../../../common/services/twi; ../../../../../../../drivers/uart; ../../../../../../../utils; ../../../../../../../drivers/usart; ../../../../../../../utils/header_files; ../../../../../../../../common/boards; ../../..; ../../../../../../../../common/services/ioport; ../../../../../../../drivers/pio; ../../../../../../../drivers/ssc; ../../../../../../../drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: wm8731_example_sram.bin
  ILINK.IlinkOutputFile: wm8731_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/sam3u/sam3u4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/pio
    ../../../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/ssc
    ../../../../../../../drivers/ssc/: ssc.c
  group sam/drivers/uart
    ../../../../../../../drivers/uart/: uart.c
  group sam/drivers/twi
    ../../../../../../../drivers/twi/: twi.c
  group sam/drivers/pmc
    ../../../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/drivers/dmac
    ../../../../../../../drivers/dmac/: dmac.c
  group sam/drivers/usart
    ../../../../../../../drivers/usart/: usart.c
  group sam/components/audio/codec/wm8731
    ../../../: wm8731.c
  group sam/components/audio/codec/wm8731/example
    ../../: xmodem.c wm8731_example.c
  group sam/boards/sam3u_ek
    ../../../../../../../boards/sam3u_ek/: init.c led.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/services/clock/sam3u
    ../../../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
