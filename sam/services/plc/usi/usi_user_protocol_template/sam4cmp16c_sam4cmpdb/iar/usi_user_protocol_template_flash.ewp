# IAR project usi_user_protocol_template_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMP16C_0 Atmel ATSAM4CMP16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4CMP16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  ICCARM.CCIncludePath2: ../../../../../../../common/services/serial/sam_uart; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../drivers/pmc; ../../../../../../boards/sam4cmp_db; ..; ../../../../../../../common/services/serial; ../../../../../../utils/cmsis/sam4cm/source/templates; ../../../../../../drivers/pdc; ../../../../../../../common/utils; ../../../../busart_if; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../drivers/pdc/pdc_uart_example; ../../../../../../drivers/uart; ../../../../../../utils; ../../../../../../drivers/tc; ../../../../pcrc; ../../../../../../utils/header_files; ../../../../buart_if; ../../../../../../../common/services/ioport; ../../..; ../../../../../../utils/cmsis/sam4cm/include; ../../../../../../drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4CMP16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMP_DB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usi_user_protocol_template_flash.bin
  ILINK.IlinkOutputFile: usi_user_protocol_template_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4cm/iar/sam4cmp16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/usart
    ../../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../../drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../../drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/pdc
    ../../../../../../drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/uart
    ../../../../../../drivers/uart/: uart.c uart.h
  group sam/services/plc/buart_if
    ../../../../buart_if/: buart_if.c buart_if.h
  group sam/services/plc/usi
    ../../../: usi.c usi.h
  group sam/services/plc/usi/usi_user_protocol_template
    ../../: usi_user_protocol_template.c
  group sam/services/plc/usi/usi_user_protocol_template/sam4cmp16c_sam4cmpdb
    ../: conf_uart_serial.h conf_buart_if.h conf_busart_if.h conf_clock.h conf_board.h conf_usi.h conf_example.h
  group sam/services/plc/usi/usi_user_protocol_template/sam4cmp16c_sam4cmpdb/iar
    ./: asf.h
  group sam/services/plc/busart_if
    ../../../../busart_if/: busart_if.c busart_if.h
  group sam/services/plc/pcrc
    ../../../../pcrc/: pcrc.c pcrc.h
  group sam/boards/sam4cmp_db
    ../../../../../../boards/sam4cmp_db/: init.c led.h sam4cmp_db.h
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../utils/cmsis/sam4cm/include/: sam4cmp16c_0.h system_sam4cm.h sam4cms16c_0.h sam4cmp8c_0.h sam4cm.h sam4cms8c_0.h sam4cms16c_1.h sam4cmp8c_1.h sam4cms8c_1.h sam4cmp16c_1.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../utils/cmsis/sam4cm/include/component/: ipc.h wdt.h uart.h trng.h supc.h pwm.h slcdc.h cmcc.h rtt.h gpbr.h pmc.h efc.h rstc.h matrix.h twi.h smc.h rtc.h chipid.h icm.h pdc.h aes.h tc.h rswdt.h adc.h spi.h usart.h pio.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../utils/cmsis/sam4cm/include/instance/: usart3.h uart0.h pwm.h smc1.h icm.h usart1.h pmc.h ipc1.h twi0.h gpbr.h rtc.h trng.h efc.h chipid.h matrix0.h ipc0.h cmcc1.h aes.h pioa.h rswdt.h matrix1.h rtt.h spi1.h rstc.h pioc.h cmcc0.h slcdc.h usart2.h uart1.h smc0.h adc.h spi0.h tc0.h supc.h tc1.h usart0.h twi1.h wdt.h piob.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../utils/cmsis/sam4cm/include/pio/: sam4cmp8c.h sam4cms16c.h sam4cmp16c.h sam4cms8c.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4cm
    ../../../../../../../common/services/clock/sam4cm/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
