# IAR project sam_services_flash_unit_tests_sam3s_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3S4C__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ..; ../../../../../drivers/uart; ../../../../../utils; ../../../../../boards/sam3s_ek; ../..; ../../../../../boards; ../../../../../utils/cmsis/sam3s/include; ../../../../../../common/boards; ../../../../../drivers/efc; ../../../../../../common/services/clock; ../../../../../drivers/pio; ../../..; ../../../../../drivers/pmc; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/header_files; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3s/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_services_flash_unit_tests_sam3s_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c
  group sam/services/flash_efc
    ../../../: flash_efc.c
  group sam/services/flash_efc/unit_tests
    ../../: unit_tests.c
  group sam/boards/sam3s_ek
    ../../../../../boards/sam3s_ek/: init.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
