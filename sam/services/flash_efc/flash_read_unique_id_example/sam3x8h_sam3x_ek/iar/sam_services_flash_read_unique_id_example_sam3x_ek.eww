<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_services_flash_read_unique_id_example_sam3x_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_services_flash_read_unique_id_example_sam3x_ek_sram.ewp</path>
	</project>
</workspace>
