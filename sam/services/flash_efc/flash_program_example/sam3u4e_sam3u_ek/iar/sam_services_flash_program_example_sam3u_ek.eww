<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_services_flash_program_example_sam3u_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_services_flash_program_example_sam3u_ek_sram.ewp</path>
	</project>
</workspace>
