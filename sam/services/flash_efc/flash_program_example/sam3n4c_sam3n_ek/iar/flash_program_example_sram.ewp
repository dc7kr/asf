# IAR project flash_program_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  ICCARM.CCIncludePath2: ..; ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../../drivers/pmc; ../../../../../drivers/efc; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3n/include; ../../..; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards/sam3n_ek; ../../../../../../common/services/gpio; ../../../../../drivers/uart; ../../../../../utils; ../../../../../utils/cmsis/sam3n/source/templates; ../../../../../drivers/usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: flash_program_example_sram.bin
  ILINK.IlinkOutputFile: flash_program_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3n/sam3n4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c efc.h
  group sam/utils
    ../../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c exceptions.h system_sam3n.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../utils/cmsis/sam3n/include/: sam3n1b.h sam3n0b.h sam3n4c.h sam3n2a.h sam3n4a.h sam3n2c.h sam3n0a.h sam3n00a.h sam3n1c.h sam3n4b.h sam3n2b.h sam3n1a.h sam3n.h sam3n0c.h sam3n00b.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../utils/cmsis/sam3n/include/component/: component_wdt.h component_uart.h component_adc.h component_dacc.h component_rtc.h component_supc.h component_rstc.h component_pdc.h component_pwm.h component_usart.h component_chipid.h component_tc.h component_gpbr.h component_rtt.h component_spi.h component_matrix.h component_pmc.h component_efc.h component_twi.h component_pio.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../utils/cmsis/sam3n/include/instance/: instance_uart0.h instance_tc0.h instance_rtt.h instance_supc.h instance_twi1.h instance_tc1.h instance_pioc.h instance_efc.h instance_pmc.h instance_matrix.h instance_rtc.h instance_usart0.h instance_twi0.h instance_piob.h instance_rstc.h instance_spi.h instance_gpbr.h instance_uart1.h instance_wdt.h instance_usart1.h instance_pwm.h instance_chipid.h instance_dacc.h instance_adc.h instance_pioa.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../utils/cmsis/sam3n/include/pio/: pio_sam3n1c.h pio_sam3n1a.h pio_sam3n00b.h pio_sam3n2a.h pio_sam3n00a.h pio_sam3n4c.h pio_sam3n2c.h pio_sam3n0a.h pio_sam3n4a.h pio_sam3n0c.h pio_sam3n1b.h pio_sam3n4b.h pio_sam3n2b.h pio_sam3n0b.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/sam3n_ek
    ../../../../../boards/sam3n_ek/: init.c led.c led.h sam3n_ek.h
  group sam/services/flash_efc
    ../../../: flash_efc.c flash_efc.h
  group sam/services/flash_efc/flash_program_example
    ../../: flash_program_example.c
  group sam/services/flash_efc/flash_program_example/sam3n4c_sam3n_ek
    ../: conf_uart_serial.h conf_board.h conf_clock.h conf_example.h
  group sam/services/flash_efc/flash_program_example/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam3n
    ../../../../../../common/services/clock/sam3n/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/boards
    ../../../../../../common/boards/: board.h
