# IAR project resistive_touch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../../common/services/spi/sam_spi; ../../../../../utils/preprocessor; ../../../../../drivers/pmc; ../../../../../components/display/ili93xx; ../..; ../../../../../drivers/ebi/smc; ../../../../../utils/fpu; ../../../../../../common/services/serial; ../../../../../drivers/spi; ../../../../../utils/cmsis/sam4e/source/templates; ../../../../../../common/utils; ../../../../../components/resistive_touch/ads7843; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../components/display/aat31xx; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../utils/cmsis/sam4e/include; ../../../../../drivers/uart; ../../../../../utils; ../../../../../../common/services/spi; ../../../../../utils/header_files; ../../../../../../common/boards; ../../..; ../../../../../../common/services/ioport; ../../../../../drivers/pio; ../../../../../boards/sam4e_ek; ..; ../../../../../drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: resistive_touch_example_flash.bin
  ILINK.IlinkOutputFile: resistive_touch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c sysclk.h genclk.h pll.h osc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/spi
    ../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../utils/cmsis/sam4e/include/: sam4e.h sam4e16c.h sam4e8e.h sam4e8c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../utils/cmsis/sam4e/include/instance/: hsmci.h wdt.h cmcc.h chipid.h tc1.h rswdt.h twi0.h pmc.h crccu.h pioc.h udp.h pwm.h efc.h acc.h rtt.h matrix.h gpbr.h aes.h spi.h afec0.h can1.h usart0.h piob.h uart1.h afec1.h pioe.h piod.h supc.h rtc.h dmac.h can0.h usart1.h gmac.h dacc.h tc2.h uart0.h tc0.h smc.h twi1.h pioa.h rstc.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../utils/cmsis/sam4e/include/component/: cmcc.h supc.h rstc.h matrix.h pdc.h usart.h wdt.h gpbr.h rtc.h dacc.h rtt.h acc.h smc.h udp.h aes.h efc.h dmac.h hsmci.h chipid.h afec.h pmc.h spi.h can.h rswdt.h gmac.h tc.h uart.h crccu.h pio.h twi.h pwm.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../utils/cmsis/sam4e/include/pio/: sam4e16e.h sam4e8c.h sam4e8e.h sam4e16c.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../utils/fpu/: fpu.h
  group sam/components/display/ili93xx
    ../../../../../components/display/ili93xx/: ili93xx.c ili9341_regs.h ili93xx.h ili9325_regs.h
  group sam/components/display/aat31xx
    ../../../../../components/display/aat31xx/: aat31xx.c aat31xx.h
  group sam/components/resistive_touch/ads7843
    ../../../../../components/resistive_touch/ads7843/: ads7843.c ads7843.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/spi
    ../../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/ebi/smc
    ../../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/services/resistive_touch
    ../../../: rtouch.c rtouch.h rtouch_ads7843.h
  group sam/services/resistive_touch/example
    ../../: rtouch_calibrate.c ads7843_example.c rtouch_calibrate.h
  group sam/services/resistive_touch/example/sam4e16e_sam4e_ek
    ../: resistive_touch_board.h conf_uart_serial.h conf_clock.h conf_aat31xx.h conf_board.h conf_ili93xx.h conf_ads7843.h conf_spi_master.h
  group sam/services/resistive_touch/example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group sam/boards/sam4e_ek
    ../../../../../boards/sam4e_ek/: init.c sam4e_ek.h led.h
