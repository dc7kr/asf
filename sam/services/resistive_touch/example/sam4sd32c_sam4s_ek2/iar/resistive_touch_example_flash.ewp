# IAR project resistive_touch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../../../common/services/spi/sam_spi; ../../../../../utils/preprocessor; ../../../../../drivers/pio; ../..; ../../../../../drivers/pmc; ../../../../../utils/cmsis/sam4s/include; ../../../../../drivers/ebi/smc; ../../../../../../common/services/serial; ../../../../../drivers/spi; ../../../../../../common/utils; ../../../../../components/resistive_touch/ads7843; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../components/display/aat31xx; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../utils/cmsis/sam4s/source/templates; ../../../../../boards/sam4s_ek2; ../../../../../drivers/uart; ../../../../../utils; ../../../../../drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../..; ../../../../../components/display/ili9325; ../../../../../../common/services/ioport; ..; ../../../../../../common/services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: resistive_touch_example_flash.bin
  ILINK.IlinkOutputFile: resistive_touch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c
  group sam/boards/sam4s_ek2
    ../../../../../boards/sam4s_ek2/: init.c led.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
  group sam/drivers/spi
    ../../../../../drivers/spi/: spi.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/ebi/smc
    ../../../../../drivers/ebi/smc/: smc.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/services/resistive_touch
    ../../../: rtouch.c
  group sam/services/resistive_touch/example
    ../../: rtouch_calibrate.c ads7843_example.c
  group sam/components/display/aat31xx
    ../../../../../components/display/aat31xx/: aat31xx.c
  group sam/components/display/ili9325
    ../../../../../components/display/ili9325/: ili9325.c
  group sam/components/resistive_touch/ads7843
    ../../../../../components/resistive_touch/ads7843/: ads7843.c
