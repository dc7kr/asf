# IAR project sam4l_qtouch_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __ATSAM4LC4C__; BOARD=SAM4L_EK; ARM_MATH_CM4=true; _QTOUCH_
  ICCARM.CCIncludePath2: ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../../thirdparty/qtouch/qdebug; ../../src; ../../../../utils/cmsis/sam4l/include; ../../../../utils/cmsis/sam4l/source/templates; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/include; ../../qtouch; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../boards/sam4l_ek; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/services/delay; ../../../../utils; ..; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../drivers/flashcalw; ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/common; ../../../../../common/services/ioport; ../../../../drivers/bpm; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __ATSAM4LC4C__; BOARD=SAM4L_EK; ARM_MATH_CM4=true; _QTOUCH_
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4l_qtouch_demo_flash.bin
  ILINK.IlinkOutputFile: sam4l_qtouch_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/devspecific/sam4/sam4l/lib/iar
    ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/lib/iar/: libsam4l-qt-iar.a
  group thirdparty/qtouch/devspecific/sam4/sam4l/common
    ../../../../../thirdparty/qtouch/devspecific/sam4/sam4l/common/: BitBangSPI_Master.c
  group thirdparty/qtouch/qdebug
    ../../../../../thirdparty/qtouch/qdebug/: QDebug_sam4l.c QDebugTransport.c
  group common/services/clock/sam4l
    ../../../../../common/services/clock/sam4l/: dfll.c sysclk.c pll.c osc.c
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/sleepmgr/sam4l
    ../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: read.c write.c
  group sam/applications/sam4l_qtouch_demo
    ../../: app.c gui.c main.c
  group sam/applications/sam4l_qtouch_demo/src
    ../../src/: bscif.c ast.c lcdca.c eic.c c42364a.c pdca.c
  group sam/applications/sam4l_qtouch_demo/qtouch
    ../../qtouch/: touch.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../utils/cmsis/sam4l/source/templates/: exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_ek
    ../../../../boards/sam4l_ek/: board_monitor.c init.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/drivers/flashcalw
    ../../../../drivers/flashcalw/: flashcalw.c
  group sam/drivers/bpm
    ../../../../drivers/bpm/: bpm.c
