# IAR project sam4e_ek_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HTTP_USED=1; FREERTOS_USED; __SAM4E16E__; TFTP_USED=1; BOARD=SAM4E_EK; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam_cm4f; ../../../../utils/header_files; ../..; ../../../../drivers/rstc; ../../../../utils/preprocessor; ../../../../components/ethernet_phy/ksz8051mnl; ../../../../../thirdparty/lwip/lwip-port-1.4.0/sam/include; ../../../../drivers/pmc; ../../../../components/display/ili93xx; ../../network; ../../../../../common/components/touch/qt/qt_i2c; ../../../../../common/services/spi/sam_spi; ../../../../drivers/ebi/smc; ../../../../utils/fpu; ../../../../../thirdparty/lwip/lwip-1.4.0/src/include; ../../../../../common/services/serial; ../../../../../common/services/clock; ../../../../drivers/spi; ../../../../utils/cmsis/sam4e/source/templates; ..; ../../../../../common/utils; ../../../../drivers/gmac; ../../../../components/resistive_touch/ads7843; ../../network/httpserver_raw; ../../../../boards; ../../../../components/display/aat31xx; ../../../../../common/utils/stdio/stdio_serial; ../../../../../thirdparty/lwip/lwip-1.4.0/src/include/lwip; ../../../../../common/services/sleepmgr; ../../../../drivers/pio; ../../../../utils/cmsis/sam4e/include; ../../../../../common/services/twi; ../../../../../common/services/delay; ../../../../drivers/uart; ../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../utils; ../../../../drivers/dacc; ../../../../drivers/tc; ../../../../../common/services/spi; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../services/resistive_touch; ../../../../../common/components/touch/qt/qt_i2c/device_specific; ../../../../../common/services/ioport; ../../../../drivers/pdc; ../../../../drivers/afec; ../../../../../thirdparty/lwip/lwip-1.4.0/src/include/ipv4; ../../../../boards/sam4e_ek; ../../../../drivers/usart; ../../../../drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sam4e_ek_demo_flash.bin
  ILINK.IlinkOutputFile: sam4e_ek_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x8000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../../../thirdparty/lwip/lwip-1.4.0/src/api/: tcpip.c err.c api_lib.c netbuf.c api_msg.c netdb.c sockets.c netifapi.c
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../../../thirdparty/lwip/lwip-1.4.0/src/core/: init.c tcp_in.c sys.c raw.c stats.c tcp_out.c lwip_timers_140.c dhcp.c netif.c udp.c mem.c dns.c pbuf.c def.c memp.c tcp.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../../../thirdparty/lwip/lwip-1.4.0/src/core/ipv4/: ip.c inet_chksum.c icmp.c ip_frag.c igmp.c ip_addr.c autoip.c inet.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../../../thirdparty/lwip/lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.0/src/include/lwip
    ../../../../../thirdparty/lwip/lwip-1.4.0/src/include/lwip/: snmp_asn1.h sys.h netif.h tcp_impl.h snmp_msg.h timers.h dhcp.h memp.h sio.h debug.h def.h raw.h netbuf.h snmp_structs.h netdb.h arch.h err.h udp.h pbuf.h tcp.h stats.h api_msg.h memp_std.h netifapi.h dns.h tcpip.h opt.h api.h sockets.h init.h mem.h snmp.h
  group thirdparty/lwip/lwip-1.4.0/src/include/ipv4/lwip
    ../../../../../thirdparty/lwip/lwip-1.4.0/src/include/ipv4/lwip/: autoip.h icmp.h igmp.h inet_chksum.h inet.h ip_frag.h ip_addr.h ip.h
  group thirdparty/lwip/lwip-1.4.0/src/include/netif
    ../../../../../thirdparty/lwip/lwip-1.4.0/src/include/netif/: ppp_oe.h etharp.h
  group thirdparty/lwip/lwip-port-1.4.0/sam
    ../../../../../thirdparty/lwip/lwip-port-1.4.0/sam/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/netif
    ../../../../../thirdparty/lwip/lwip-port-1.4.0/sam/netif/: ethernetif_sam4.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/arch
    ../../../../../thirdparty/lwip/lwip-port-1.4.0/sam/include/arch/: cc.h perf.h sys_arch.h
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/netif
    ../../../../../thirdparty/lwip/lwip-port-1.4.0/sam/include/netif/: ethernetif.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/: timers.c list.c tasks.c queue.c croutine.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam_cm4f
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../../thirdparty/freertos/freertos-7.0.0/source/include/: FreeRTOS.h queue.h croutine.h projdefs.h mpu_wrappers.h StackMacros.h list.h timers.h task.h portable.h semphr.h
  group sam/applications/sam4e_ek_demo
    ../../: task_webserver.c task_qtouch_cpn.c task_dsp.c task_gfx.c main.c FreeRTOSConfig.h task_demo.h logo_atmel.h sound.h lwipopts.h
  group sam/applications/sam4e_ek_demo/network
    ../../network/: timer_mgt_sam.c ethernet_sam.c timer_mgt_sam.h ethernet_sam.h
  group sam/applications/sam4e_ek_demo/network/httpserver_raw
    ../../network/httpserver_raw/: fsdata.c fs.c cgi.c httpd.c style.h fs.h jqflot.h index.h fsdata.h favicon.h cgi.h atmel.h excan.h jquery.h httpd.h
  group sam/applications/sam4e_ek_demo/sam4e16e_sam4e_ek
    ../: conf_uart_serial.h conf_qt_i2c.h conf_lwip_threads.h conf_board.h conf_eth.h conf_clock.h conf_sleepmgr.h conf_aat31xx.h conf_spi_master.h conf_ili93xx.h conf_ads7843.h
  group sam/applications/sam4e_ek_demo/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group sam/components/resistive_touch/ads7843
    ../../../../components/resistive_touch/ads7843/: ads7843.c ads7843.h
  group sam/components/display/ili93xx
    ../../../../components/display/ili93xx/: ili93xx.c ili9341_regs.h ili9325_regs.h ili93xx.h
  group sam/components/display/aat31xx
    ../../../../components/display/aat31xx/: aat31xx.c aat31xx.h
  group sam/components/ethernet_phy
    ../../../../components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../components/ethernet_phy/ksz8051mnl/: ethernet_phy.c ethernet_phy.h
  group sam/drivers/ebi/smc
    ../../../../drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/afec
    ../../../../drivers/afec/: afec.c afec.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/twi
    ../../../../drivers/twi/: twi.c twi.h
  group sam/drivers/rstc
    ../../../../drivers/rstc/: rstc.c rstc.h
  group sam/drivers/gmac
    ../../../../drivers/gmac/: gmac.c gmac.h
  group sam/drivers/dacc
    ../../../../drivers/dacc/: dacc.c dacc.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c tc.h
  group sam/drivers/pdc
    ../../../../drivers/pdc/: pdc.c pdc.h
  group sam/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group sam/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../utils/cmsis/sam4e/include/: sam4e16e.h sam4e8c.h sam4e8e.h sam4e16c.h sam4e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../utils/cmsis/sam4e/include/instance/: afec0.h matrix.h spi.h smc.h dacc.h pmc.h hsmci.h tc2.h acc.h can1.h chipid.h rtc.h tc1.h twi0.h can0.h rtt.h gmac.h uart0.h rswdt.h pwm.h piob.h pioc.h tc0.h rstc.h dmac.h twi1.h supc.h uart1.h pioa.h usart1.h efc.h udp.h usart0.h wdt.h pioe.h aes.h cmcc.h afec1.h crccu.h gpbr.h piod.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../utils/cmsis/sam4e/include/pio/: sam4e16e.h sam4e16c.h sam4e8e.h sam4e8c.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../utils/cmsis/sam4e/include/component/: rswdt.h rtc.h afec.h matrix.h dacc.h supc.h gmac.h hsmci.h pdc.h smc.h wdt.h spi.h dmac.h usart.h udp.h tc.h gpbr.h cmcc.h uart.h can.h crccu.h efc.h rtt.h rstc.h pio.h pwm.h aes.h chipid.h acc.h pmc.h twi.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/services/resistive_touch
    ../../../../services/resistive_touch/: rtouch.c rtouch.h rtouch_ads7843.h
  group sam/boards/sam4e_ek
    ../../../../boards/sam4e_ek/: sam4e_ek.h led.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h pll.h genclk.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/twi
    ../../../../../common/services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../common/services/twi/sam_twi/: twi_master.h twi_slave.h
  group common/components/touch/qt/qt_i2c
    ../../../../../common/components/touch/qt/qt_i2c/: qt_i2c.c qt_i2c.h
  group common/components/touch/qt/qt_i2c/device_specific
    ../../../../../common/components/touch/qt/qt_i2c/device_specific/: QT2160.h
  group common/boards
    ../../../../../common/boards/: board.h
