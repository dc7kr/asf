# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../utils/cmsis/sam4n/include; ../../../../boards/sam4n_xplained_pro; ../../../../utils/cmsis/sam4n/source/templates; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../drivers/supc; ../../../../../common/utils; ..; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/serial/sam_uart; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../utils/cmsis/sam4n/source/templates/: exceptions.c system_sam4n.c exceptions.h system_sam4n.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../utils/cmsis/sam4n/include/: sam4n16c.h sam4n16b.h sam4n8b.h sam4n.h sam4n8c.h sam4n8a.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../utils/cmsis/sam4n/include/component/: component_twi.h component_efc.h component_pmc.h component_tc.h component_matrix.h component_rstc.h component_pdc.h component_spi.h component_gpbr.h component_usart.h component_rtc.h component_pio.h component_wdt.h component_dacc.h component_adc.h component_uart.h component_supc.h component_pwm.h component_rtt.h component_chipid.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../utils/cmsis/sam4n/include/instance/: instance_chipid.h instance_tc1.h instance_usart1.h instance_gpbr.h instance_rtt.h instance_matrix.h instance_wdt.h instance_dacc.h instance_uart3.h instance_spi.h instance_uart1.h instance_efc.h instance_pmc.h instance_pioa.h instance_pioc.h instance_uart0.h instance_rtc.h instance_piob.h instance_adc.h instance_twi1.h instance_uart2.h instance_supc.h instance_rstc.h instance_tc0.h instance_usart0.h instance_pwm.h instance_twi0.h instance_usart2.h instance_twi2.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../utils/cmsis/sam4n/include/pio/: pio_sam4n8a.h pio_sam4n8c.h pio_sam4n16c.h pio_sam4n16b.h pio_sam4n8b.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/boards/sam4n_xplained_pro
    ../../../../boards/sam4n_xplained_pro/: init.c sam4n_xplained_pro.h led.h
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/sam4n16c_sam4n_xplained_pro
    ../: low_power_board.c conf_uart_serial.h conf_clock.h conf_board.h low_power_board.h
  group sam/applications/sam_low_power/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4n
    ../../../../../common/services/clock/sam4n/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
