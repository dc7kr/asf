# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../utils/cmsis/sam3s/include; ../../../../drivers/gpbr; ../../../../drivers/supc; ../../../../../common/utils; ../../../../utils/cmsis/sam3s/source/templates; ../../../../drivers/wdt; ../../../../boards/sam3s_ek; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/gpio; ..; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../../common/services/serial; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/sam3s4c_sam3s_ek
    ../: low_power_board.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../utils/cmsis/sam3s/source/templates/: exceptions.c system_sam3s.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/boards/sam3s_ek
    ../../../../boards/sam3s_ek/: init.c led.c
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
