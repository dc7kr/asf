<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\low_power_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\low_power_sram.ewp</path>
	</project>
</workspace>
