# IAR project low_power_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../utils/cmsis/sam3n/include; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../boards/sam3n_ek; ../../../../../common/services/gpio; ..; ../../../../drivers/uart; ../../../../utils; ../../../../utils/cmsis/sam3n/source/templates; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_sram.bin
  ILINK.IlinkOutputFile: low_power_sram.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3n/sam3n4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c
  group sam/boards/sam3n_ek
    ../../../../boards/sam3n_ek/: led.c init.c
  group sam/applications/sam_low_power
    ../../: low_power_example.c
  group sam/applications/sam_low_power/sam3n4c_sam3n_ek
    ../: low_power_board.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group common/services/clock/sam3n
    ../../../../../common/services/clock/sam3n/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
