# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../../../../../common/services/serial/sam_uart; ../../../../utils/cmsis/sam3u/source/templates; ../../../../utils/preprocessor; ../..; ../../../../drivers/pio; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../boards/sam3u_ek; ../../../../utils/cmsis/sam3u/include; ../../../../../common/services/gpio; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c
  group sam/boards/sam3u_ek
    ../../../../boards/sam3u_ek/: init.c led.c
  group sam/applications/sam_low_power
    ../../: low_power_example.c
  group sam/applications/sam_low_power/sam3u4e_sam3u_ek
    ../: low_power_board.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group common/services/clock/sam3u
    ../../../../../common/services/clock/sam3u/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
