# IAR project low_power_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../..; ../../../../drivers/pmc; ../../../../drivers/efc; ../../../../utils/fpu; ..; ../../../../../common/services/serial; ../../../../drivers/gpbr; ../../../../boards/samg53_xplained_pro; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../utils/cmsis/samg/samg53/include; ../../../../drivers/uart; ../../../../utils/cmsis/samg/samg53/source/templates; ../../../../utils; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: low_power_flash.bin
  ILINK.IlinkOutputFile: low_power_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samg/samg53n19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/boards/samg53_xplained_pro
    ../../../../boards/samg53_xplained_pro/: board_init.c led.h samg53_xplained_pro.h
  group sam/applications/sam_low_power
    ../../: main.c
  group sam/applications/sam_low_power/samg53g19_samg53_xplained_pro
    ../: low_power_board.c conf_uart_serial.h conf_clock.h conf_board.h low_power_board.h
  group sam/applications/sam_low_power/samg53g19_samg53_xplained_pro/iar
    ./: asf.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../../utils/cmsis/samg/samg53/source/templates/: exceptions.c system_samg53.c system_samg53.h exceptions.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../../utils/cmsis/samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../../utils/cmsis/samg/samg53/include/: samg53g19.h samg53n19.h samg53.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../../utils/cmsis/samg/samg53/include/component/: component_i2sc.h component_adc.h component_chipid.h component_pio.h component_usart.h component_wdt.h component_twi.h component_tc.h component_twihs.h component_spi.h component_uart.h component_pmc.h component_rstc.h component_pdmic.h component_rtc.h component_supc.h component_mem2mem.h component_matrix.h component_efc.h component_pdc.h component_gpbr.h component_rtt.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../../utils/cmsis/samg/samg53/include/instance/: instance_pdmic0.h instance_tc0.h instance_efc.h instance_matrix.h instance_rtc.h instance_pdmic1.h instance_tc1.h instance_mem2mem.h instance_uart1.h instance_twi1.h instance_gpbr.h instance_twi0.h instance_supc.h instance_pmc.h instance_rstc.h instance_spi.h instance_pioa.h instance_chipid.h instance_adc.h instance_i2sc0.h instance_uart0.h instance_usart.h instance_piob.h instance_wdt.h instance_rtt.h instance_i2sc1.h instance_twi2.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../../utils/cmsis/samg/samg53/include/pio/: pio_samg53g19.h pio_samg53n19.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/samg
    ../../../../../common/services/clock/samg/: sysclk.c osc.h genclk.h sysclk.h pll.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
