# IAR project starter_kit_bootloader_demo_main_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SD_MMC_ENABLE; ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../drivers/adc; ../../../../../utils/cmsis/sam4n/include; ../../../../../../common/services/spi/sam_spi; ../../../../../boards/sam4n_xplained_pro; ../../../../../utils/cmsis/sam4n/source/templates; ../../../../../drivers/rstc; ../../../../../utils/preprocessor; ../../../../../drivers/pio; ../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../utils/header_files; ../../../../../drivers/efc; ../../../../../../common/services/gpio; ../../../../../../common/components/memory/eeprom/at30tse75x; ../../../../../../common/services/serial; ../../../../../drivers/gpbr; ../../../../../services/flash_efc; ../../../../../drivers/spi; ../../../../../drivers/supc; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../..; ../../../../../drivers/wdt; ../../../../../../common/components/memory/sd_mmc; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../../common/services/twi; ../../../../../../common/services/ioport; ../../../../../../common/services/delay; ../../../../../drivers/uart; ../../../../../utils; ../../../../../drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../drivers/rtc; ../../../../../drivers/pmc; ../../../../../../common/components/display/ssd1306; ../../../../../../common/services/spi; ../../../../../../common/services/storage/ctrl_access; ../../../../../drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: starter_kit_bootloader_demo_main_flash.bin
  ILINK.IlinkOutputFile: starter_kit_bootloader_demo_main_flash.out
  ILINK.IlinkIcfFile: ../linker_scripts/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/eeprom/at30tse75x
    ../../../../../../common/components/memory/eeprom/at30tse75x/: at30tse75x.c at30tse75x.h
  group common/components/memory/sd_mmc
    ../../../../../../common/components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c sd_mmc_spi.c sd_mmc.h sd_mmc_spi.h sd_mmc_mem.h sd_mmc_protocol.h
  group common/components/display/ssd1306
    ../../../../../../common/components/display/ssd1306/: ssd1306.c font.c font.h ssd1306.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/storage/ctrl_access
    ../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4n
    ../../../../../../common/services/clock/sam4n/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/twi
    ../../../../../../common/services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../common/services/twi/sam_twi/: twi_slave.h twi_master.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c integer.h ff.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c flash_efc.h
  group sam/applications/starter_kit_bootloader_demo/main
    ../../: multi_language_display.c main.c unicode_string.h unicode_font_table.h multi_language_display.h
  group sam/applications/starter_kit_bootloader_demo/main/sam4n16c_sam4n_xplained_pro
    ../: conf_sd_mmc.h conf_uart_serial.h conf_sleepmgr.h conf_clock.h conf_board.h conf_ssd1306.h conf_example.h conf_access.h conf_spi_master.h conf_fatfs.h
  group sam/applications/starter_kit_bootloader_demo/main/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group sam/drivers/wdt
    ../../../../../drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/spi
    ../../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/rtc
    ../../../../../drivers/rtc/: rtc.c rtc.h
  group sam/drivers/rstc
    ../../../../../drivers/rstc/: rstc.c rstc.h
  group sam/drivers/adc
    ../../../../../drivers/adc/: adc2.c adc2.h
  group sam/drivers/twi
    ../../../../../drivers/twi/: twi.c twi.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/supc
    ../../../../../drivers/supc/: supc.c supc.h
  group sam/utils
    ../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../../utils/cmsis/sam4n/source/templates/: system_sam4n.c exceptions.c system_sam4n.h exceptions.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../../utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../../utils/cmsis/sam4n/include/: sam4n16b.h sam4n.h sam4n16c.h sam4n8c.h sam4n8a.h sam4n8b.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../../utils/cmsis/sam4n/include/instance/: instance_efc.h instance_matrix.h instance_usart2.h instance_pwm.h instance_twi2.h instance_supc.h instance_usart1.h instance_rstc.h instance_usart0.h instance_adc.h instance_tc1.h instance_twi0.h instance_dacc.h instance_uart3.h instance_pioa.h instance_wdt.h instance_gpbr.h instance_uart2.h instance_pmc.h instance_pioc.h instance_twi1.h instance_tc0.h instance_rtt.h instance_uart0.h instance_uart1.h instance_spi.h instance_piob.h instance_chipid.h instance_rtc.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../../utils/cmsis/sam4n/include/pio/: pio_sam4n8b.h pio_sam4n16b.h pio_sam4n16c.h pio_sam4n8c.h pio_sam4n8a.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../../utils/cmsis/sam4n/include/component/: component_dacc.h component_rtt.h component_wdt.h component_usart.h component_chipid.h component_efc.h component_pdc.h component_spi.h component_twi.h component_pio.h component_gpbr.h component_tc.h component_adc.h component_pmc.h component_pwm.h component_matrix.h component_rstc.h component_supc.h component_uart.h component_rtc.h
  group sam/utils/preprocessor
    ../../../../../utils/preprocessor/: mrepeat.h stringz.h preprocessor.h tpaste.h
  group sam/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam/boards/sam4n_xplained_pro
    ../../../../../boards/sam4n_xplained_pro/: init.c sam4n_xplained_pro.h led.h
