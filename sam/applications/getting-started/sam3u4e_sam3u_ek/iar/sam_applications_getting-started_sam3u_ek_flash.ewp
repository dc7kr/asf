# IAR project sam_applications_getting-started_sam3u_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../drivers/pmc; ../..; ../../../../utils/cmsis/sam3u/source/templates; ../../../../utils; ../../../../../common/services/clock; ..; ../../../../boards; ../../../../utils/header_files; ../../../../../common/boards; ../../../../boards/sam3u_ek; ../../../../utils/cmsis/sam3u/include; ../../../../drivers/pio; ../../../../drivers/tc; ../../../../drivers/uart; ../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; BOARD=SAM3U_EK
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_applications_getting-started_sam3u_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/syscalls/iar
    ../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c
  group sam/boards/sam3u_ek
    ../../../../boards/sam3u_ek/: init.c
  group sam/applications/getting-started
    ../../: main.c
  group common/services/clock/sam3u
    ../../../../../common/services/clock/sam3u/: sysclk.c
