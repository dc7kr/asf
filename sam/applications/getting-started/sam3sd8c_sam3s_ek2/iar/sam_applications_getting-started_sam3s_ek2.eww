<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_applications_getting-started_sam3s_ek2_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_applications_getting-started_sam3s_ek2_sram.ewp</path>
	</project>
</workspace>
