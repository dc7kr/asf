# IAR project sam_applications_getting-started_sam3s_ek2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../utils/header_files; ../..; ../../../../utils; ../../../../../common/services/clock; ../../../../drivers/tc; ../../../../boards; ..; ../../../../../common/boards; ../../../../utils/cmsis/sam3s8/source/templates; ../../../../drivers/pio; ../../../../utils/cmsis/sam3s8/include; ../../../../drivers/pmc; ../../../../drivers/uart; ../../../../boards/sam3s_ek2; ../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_applications_getting-started_sam3s_ek2_flash.elf
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/syscalls/iar
    ../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam3s_ek2
    ../../../../boards/sam3s_ek2/: init.c
  group sam/applications/getting-started
    ../../: main.c
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c
