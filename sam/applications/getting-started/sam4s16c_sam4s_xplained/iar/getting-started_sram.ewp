# IAR project getting-started_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../utils/cmsis/sam4s/include; ../../../../../common/services/serial; ../../../../../common/utils; ..; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../common/services/gpio; ../../../../utils/cmsis/sam4s/source/templates; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/tc; ../../../../drivers/usart; ../../../../utils/header_files; ../../../../../common/boards; ../../../../../common/services/ioport; ../../../../drivers/pio; ../../../../boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: getting-started_sram.bin
  ILINK.IlinkOutputFile: getting-started_sram.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c
  group sam/boards/sam4s_xplained
    ../../../../boards/sam4s_xplained/: init.c led.c
  group sam/applications/getting-started
    ../../: main.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
