# IAR project getting-started_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ..; ../../../../drivers/uart; ../../../../utils/cmsis/sam3s/include; ../../../../utils; ../../../../boards/sam3s_ek; ../../../../../common/services/clock; ../../../../drivers/tc; ../../../../boards; ../../../../utils/header_files; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../drivers/pio; ../../../../../common/utils; ../..; ../../../../../common/services/gpio; ../../../../utils/cmsis/sam3s/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK
  OBJCOPY.OOCOutputFile: getting-started_flash.bin
  ILINK.IlinkOutputFile: getting-started_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../utils/cmsis/sam3s/source/templates/: exceptions.c system_sam3s.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/syscalls/iar
    ../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam3s_ek
    ../../../../boards/sam3s_ek/: init.c
  group sam/applications/getting-started
    ../../: main.c
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
