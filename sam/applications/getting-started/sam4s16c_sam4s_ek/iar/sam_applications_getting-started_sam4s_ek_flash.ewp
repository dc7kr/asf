# IAR project sam_applications_getting-started_sam4s_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../utils/cmsis/sam4s/source/templates; ..; ../..; ../../../../utils; ../../../../../common/services/clock; ../../../../drivers/tc; ../../../../boards; ../../../../utils/header_files; ../../../../../common/boards; ../../../../drivers/pio; ../../../../drivers/pmc; ../../../../boards/sam4s_ek; ../../../../drivers/uart; ../../../../utils/cmsis/sam4s/include; ../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_applications_getting-started_sam4s_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/syscalls/iar
    ../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c
  group sam/drivers/tc
    ../../../../drivers/tc/: tc.c
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c
  group sam/boards/sam4s_ek
    ../../../../boards/sam4s_ek/: init.c
  group sam/applications/getting-started
    ../../: main.c
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c
