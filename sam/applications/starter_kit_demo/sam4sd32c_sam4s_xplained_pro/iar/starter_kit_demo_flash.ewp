# IAR project starter_kit_demo_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SD_MMC_ENABLE; BOARD=SAM4S_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../drivers/adc; ../..; ../../../../../common/services/spi/sam_spi; ../../../../../common/components/memory/sd_mmc; ../../../../utils/preprocessor; ../../../../drivers/pmc; ../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../utils/cmsis/sam4s/include; ../../../../utils/header_files; ../../../../drivers/efc; ../../../../../common/services/twi; ../../../../../common/components/memory/eeprom/at30tse75x; ../../../../../common/services/serial; ../../../../drivers/gpbr; ..; ../../../../drivers/spi; ../../../../drivers/supc; ../../../../../common/utils; ../../../../drivers/wdt; ../../../../../common/services/clock; ../../../../boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/gpio; ../../../../../common/services/ioport; ../../../../utils/cmsis/sam4s/source/templates; ../../../../../common/services/delay; ../../../../drivers/uart; ../../../../utils; ../../../../drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../../drivers/rtc; ../../../../drivers/pio; ../../../../../common/components/display/ssd1306; ../../../../boards/sam4s_xplained_pro; ../../../../../common/services/spi; ../../../../../common/services/storage/ctrl_access; ../../../../drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: starter_kit_demo_flash.bin
  ILINK.IlinkOutputFile: starter_kit_demo_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/uart
    ../../../../drivers/uart/: uart.c uart.h
  group sam/drivers/adc
    ../../../../drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/twi
    ../../../../drivers/twi/: twi.c twi.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/rtc
    ../../../../drivers/rtc/: rtc.c rtc.h
  group sam/drivers/spi
    ../../../../drivers/spi/: spi.c spi.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/wdt
    ../../../../drivers/wdt/: wdt.c wdt.h
  group sam/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../utils/cmsis/sam4s/include/: sam4s2a.h sam4sa16b.h sam4s2c.h sam4s16b.h sam4sd32c.h sam4sd16c.h sam4sd16b.h sam4s.h sam4s8b.h sam4sd32b.h sam4sa16c.h sam4s4b.h system_sam4s.h sam4s4c.h sam4s4a.h sam4s2b.h sam4s16c.h sam4s8c.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../utils/cmsis/sam4s/include/component/: component_chipid.h component_matrix.h component_rstc.h component_twi.h component_uart.h component_wdt.h component_pmc.h component_pdc.h component_udp.h component_pwm.h component_cmcc.h component_smc.h component_gpbr.h component_adc.h component_ssc.h component_pio.h component_dacc.h component_supc.h component_rtc.h component_efc.h component_usart.h component_rtt.h component_spi.h component_tc.h component_crccu.h component_acc.h component_hsmci.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../utils/cmsis/sam4s/include/pio/: pio_sam4s8c.h pio_sam4s2c.h pio_sam4sa16c.h pio_sam4s4c.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4s16b.h pio_sam4sa16b.h pio_sam4sd16b.h pio_sam4s4a.h pio_sam4s16c.h pio_sam4s2b.h pio_sam4s8b.h pio_sam4s4b.h pio_sam4sd32c.h pio_sam4sd16c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../utils/cmsis/sam4s/include/instance/: instance_rstc.h instance_hsmci.h instance_spi.h instance_smc.h instance_pwm.h instance_rtc.h instance_uart0.h instance_efc1.h instance_tc1.h instance_dacc.h instance_chipid.h instance_matrix.h instance_uart1.h instance_pioc.h instance_usart1.h instance_piob.h instance_pioa.h instance_tc0.h instance_supc.h instance_rtt.h instance_acc.h instance_gpbr.h instance_cmcc.h instance_twi0.h instance_usart0.h instance_adc.h instance_crccu.h instance_wdt.h instance_pmc.h instance_udp.h instance_twi1.h instance_efc0.h instance_ssc.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/boards/sam4s_xplained_pro
    ../../../../boards/sam4s_xplained_pro/: init.c sam4s_xplained_pro.h
  group sam/applications/starter_kit_demo
    ../../: main.c
  group sam/applications/starter_kit_demo/sam4sd32c_sam4s_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_ssd1306.h conf_fatfs.h conf_access.h conf_sd_mmc.h
  group sam/applications/starter_kit_demo/sam4sd32c_sam4s_xplained_pro/iar
    ./: asf.h
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/twi
    ../../../../../common/services/twi/: twi_slave.h twi_master.h
  group common/services/twi/sam_twi
    ../../../../../common/services/twi/sam_twi/: twi_master.h twi_slave.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/components/display/ssd1306
    ../../../../../common/components/display/ssd1306/: font.c ssd1306.c font.h ssd1306.h
  group common/components/memory/sd_mmc
    ../../../../../common/components/memory/sd_mmc/: sd_mmc.c sd_mmc_mem.c sd_mmc_spi.c sd_mmc_protocol.h sd_mmc.h sd_mmc_mem.h sd_mmc_spi.h
  group common/components/memory/eeprom/at30tse75x
    ../../../../../common/components/memory/eeprom/at30tse75x/: at30tse75x.c at30tse75x.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../common/boards/: board.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c diskio.h integer.h ffconf.h ff.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
