<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_utils_cmsis_cm3_cmsis_example_sam3x_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_utils_cmsis_cm3_cmsis_example_sam3x_ek_sram.ewp</path>
	</project>
</workspace>
