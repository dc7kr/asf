<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_utils_cmsis_cm3_cmsis_example_sam3s_ek2_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_utils_cmsis_cm3_cmsis_example_sam3s_ek2_sram.ewp</path>
	</project>
</workspace>
