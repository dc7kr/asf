# IAR project sam_utils_cmsis_cm3_nvic_example_sam3s_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../sam3s/include; ../../../../../drivers/uart; ../..; ../../../..; ../../../../../boards/sam3s_ek; ../../../../../boards; ../../../../header_files; ..; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../../common/boards; ../../../../../../common/services/gpio; ../../../sam3s/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_utils_cmsis_cm3_nvic_example_sam3s_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3s/source/templates
    ../../../sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/utils/syscalls/iar
    ../../../../syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c
  group sam/boards/sam3s_ek
    ../../../../../boards/sam3s_ek/: init.c
