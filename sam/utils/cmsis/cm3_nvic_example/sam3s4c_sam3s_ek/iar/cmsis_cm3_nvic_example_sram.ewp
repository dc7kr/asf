# IAR project cmsis_cm3_nvic_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../header_files; ../../../../../drivers/uart; ../..; ../../../..; ../../../../../boards/sam3s_ek; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../drivers/usart; ../../../sam3s/include; ..; ../../../../preprocessor; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../../../sam3s/source/templates; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_nvic_example_sram.bin
  ILINK.IlinkOutputFile: cmsis_cm3_nvic_example_sram.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3s/sam3s4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../sam3s/source/templates/: exceptions.c system_sam3s.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/boards/sam3s_ek
    ../../../../../boards/sam3s_ek/: led.c init.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio.c pio_handler.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../../drivers/usart/: usart.c
