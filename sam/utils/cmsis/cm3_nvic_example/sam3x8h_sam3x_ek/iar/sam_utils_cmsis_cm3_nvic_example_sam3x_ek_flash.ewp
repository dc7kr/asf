# IAR project sam_utils_cmsis_cm3_nvic_example_sam3x_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../drivers/uart; ../..; ../../../..; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../sam3x/include; ..; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../boards/sam3x_ek; ../../../../../../common/services/gpio; ../../../sam3x/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_utils_cmsis_cm3_nvic_example_sam3x_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/utils/syscalls/iar
    ../../../../syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam3x_ek
    ../../../../../boards/sam3x_ek/: init.c
