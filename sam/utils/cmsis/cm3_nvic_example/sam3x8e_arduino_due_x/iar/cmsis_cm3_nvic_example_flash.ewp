# IAR project cmsis_cm3_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../../drivers/uart; ../..; ../../../..; ../../../../../../common/services/gpio; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../sam3x/include; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../boards; ../../../../../../common/utils; ..; ../../../../../boards/arduino_due_x; ../../../sam3x/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  OBJCOPY.OOCOutputFile: cmsis_cm3_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm3_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/cmsis/cm3_nvic_example
    ../../: main.c
  group sam/utils/syscalls/iar
    ../../../../syscalls/iar/: dlib_lowlevel.c
  group sam/boards/arduino_due_x
    ../../../../../boards/arduino_due_x/: init.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
