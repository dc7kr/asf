# IAR project cmsis_cm4_nvic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../sam4s/source/templates; ../../../../../drivers/uart; ../../../..; ../..; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../boards; ../../../../../boards/sam4s_ek; ../../../../../../common/utils; ../../../sam4s/include; ..; ../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  OBJCOPY.OOCOutputFile: cmsis_cm4_nvic_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_nvic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/cm4_nvic_example
    ../../: main.c
  group sam/utils/syscalls/iar
    ../../../../syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam4s_ek
    ../../../../../boards/sam4s_ek/: init.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
