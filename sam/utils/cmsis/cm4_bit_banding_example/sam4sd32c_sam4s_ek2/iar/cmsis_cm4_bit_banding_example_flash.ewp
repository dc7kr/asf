# IAR project cmsis_cm4_bit_banding_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK2; __SAM4SD32C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../sam4s/source/templates; ../../../../../boards/sam4s_ek2; ../../../..; ../../../../../../common/services/clock; ../../../../../boards; ..; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/pio; ../../../../../../common/utils; ../../../sam4s/include; ../../../../header_files; ../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK2; __SAM4SD32C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_bit_banding_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_bit_banding_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam4s_ek2
    ../../../../../boards/sam4s_ek2/: init.c led.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/cm4_bit_banding_example
    ../../: main.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
