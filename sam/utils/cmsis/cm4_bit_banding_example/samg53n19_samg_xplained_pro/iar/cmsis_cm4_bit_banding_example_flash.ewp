# IAR project cmsis_cm4_bit_banding_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG53N19 Atmel SAMG53N19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../samg/samg53/source/templates; ../../../..; ../../../../fpu; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../boards/samg53_xplained_pro; ../../../../../../common/services/clock; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ..; ../../../../../../common/utils; ../../../samg/samg53/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAMG53N19__; BOARD=SAMG53_XPLAINED_PRO; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_bit_banding_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_bit_banding_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/samg/samg53n19/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/samg/samg53/source/templates
    ../../../samg/samg53/source/templates/: exceptions.c system_samg53.c exceptions.h system_samg53.h
  group sam/utils/cmsis/samg/samg53/source/templates/iar
    ../../../samg/samg53/source/templates/iar/: startup_samg53.c
  group sam/utils/cmsis/samg/samg53/include
    ../../../samg/samg53/include/: samg53n19.h samg53g19.h samg53.h
  group sam/utils/cmsis/samg/samg53/include/instance
    ../../../samg/samg53/include/instance/: instance_pdmic0.h instance_pdmic1.h instance_supc.h instance_i2sc1.h instance_chipid.h instance_rtt.h instance_rstc.h instance_pmc.h instance_uart0.h instance_twi2.h instance_adc.h instance_tc1.h instance_gpbr.h instance_tc0.h instance_mem2mem.h instance_uart1.h instance_spi.h instance_efc.h instance_twi0.h instance_rtc.h instance_piob.h instance_twi1.h instance_matrix.h instance_wdt.h instance_usart.h instance_i2sc0.h instance_pioa.h
  group sam/utils/cmsis/samg/samg53/include/component
    ../../../samg/samg53/include/component/: component_adc.h component_pmc.h component_efc.h component_pdc.h component_rtc.h component_mem2mem.h component_uart.h component_matrix.h component_wdt.h component_twihs.h component_usart.h component_pio.h component_twi.h component_gpbr.h component_i2sc.h component_tc.h component_spi.h component_chipid.h component_rtt.h component_supc.h component_rstc.h component_pdmic.h
  group sam/utils/cmsis/samg/samg53/include/pio
    ../../../samg/samg53/include/pio/: pio_samg53g19.h pio_samg53n19.h
  group sam/utils/cmsis/cm4_bit_banding_example
    ../../: main.c
  group sam/utils/cmsis/cm4_bit_banding_example/samg53n19_samg_xplained_pro
    ../: conf_clock.h conf_board.h
  group sam/utils/cmsis/cm4_bit_banding_example/samg53n19_samg_xplained_pro/iar
    ./: asf.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/utils/fpu
    ../../../../fpu/: fpu.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
  group sam/boards/samg53_xplained_pro
    ../../../../../boards/samg53_xplained_pro/: board_init.c samg53_xplained_pro.h led.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group common/services/clock
    ../../../../../../common/services/clock/: genclk.h sysclk.h osc.h pll.h
  group common/services/clock/samg
    ../../../../../../common/services/clock/samg/: sysclk.c genclk.h sysclk.h pll.h osc.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
