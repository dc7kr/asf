# IAR project cmsis_cm4_bit_banding_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; __SAM4E16E__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../..; ../../../../fpu; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../preprocessor; ../../../../../../common/services/clock; ../../../../../../common/services/ioport; ..; ../../../sam4e/source/templates; ../../../sam4e/include; ../../../../../../common/utils; ../../../../../boards/sam4e_ek; ../../../../../drivers/pmc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; __SAM4E16E__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm4_bit_banding_example_flash.bin
  ILINK.IlinkOutputFile: cmsis_cm4_bit_banding_example_flash.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c sysclk.h genclk.h pll.h osc.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/boards/sam4e_ek
    ../../../../../boards/sam4e_ek/: init.c sam4e_ek.h led.h
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/utils
    ../../../../: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../sam4e/source/templates/: exceptions.c system_sam4e.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../sam4e/include/: sam4e16e.h sam4e.h sam4e16c.h sam4e8e.h sam4e8c.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../sam4e/include/instance/: pioa.h efc.h pioc.h spi.h afec1.h rswdt.h twi0.h gpbr.h usart1.h aes.h can1.h dacc.h cmcc.h uart0.h piob.h pwm.h rtc.h pioe.h tc2.h matrix.h wdt.h can0.h rstc.h udp.h piod.h pmc.h dmac.h acc.h tc0.h rtt.h tc1.h chipid.h afec0.h smc.h gmac.h supc.h twi1.h crccu.h hsmci.h uart1.h usart0.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../sam4e/include/component/: gpbr.h rtt.h afec.h wdt.h can.h dacc.h usart.h aes.h uart.h hsmci.h pdc.h smc.h chipid.h supc.h tc.h rstc.h pwm.h crccu.h gmac.h acc.h efc.h cmcc.h twi.h rtc.h matrix.h dmac.h udp.h rswdt.h spi.h pio.h pmc.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../sam4e/include/pio/: sam4e16c.h sam4e8e.h sam4e8c.h sam4e16e.h
  group sam/utils/cmsis/cm4_bit_banding_example
    ../../: main.c
  group sam/utils/cmsis/cm4_bit_banding_example/sam4e16e_sam4e_ek
    ../: conf_clock.h conf_board.h
  group sam/utils/cmsis/cm4_bit_banding_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group sam/utils/fpu
    ../../../../fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../preprocessor/: mrepeat.h stringz.h preprocessor.h tpaste.h
  group sam/utils/header_files
    ../../../../header_files/: io.h
