# IAR project cmsis_cm3_bit_banding_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../sam3u/source/templates; ../../../..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../header_files; ../../../../../../common/boards; ../../../../../boards/sam3u_ek; ../../../../preprocessor; ../../../sam3u/include; ../../../../../../common/services/ioport; ../../../../../drivers/pmc; ../../../../../drivers/pio; ..; ../../../../../../common/utils; ../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: cmsis_cm3_bit_banding_example_sram.bin
  ILINK.IlinkOutputFile: cmsis_cm3_bit_banding_example_sram.out
  ILINK.IlinkIcfFile: ../../../../linker_scripts/sam3u/sam3u4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: led.c init.c
  group sam/drivers/pio
    ../../../../../drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../drivers/pmc/: pmc.c sleep.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/cmsis/cm3_bit_banding_example
    ../../: main.c
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
