<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_pdc_pdc_uart_example_sam3n_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_pdc_pdc_uart_example_sam3n_ek_sram.ewp</path>
	</project>
</workspace>
