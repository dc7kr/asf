# IAR project dmac_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/cmsis/sam3u/source/templates; ../../..; ../../../../pmc; ../../../../../../common/services/serial; ../../../../../../common/utils; ..; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards/sam3u_ek; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/sam3u/include; ../../../../../../common/services/gpio; ../../../../uart; ../../../../../utils; ../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; ../../../../usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dmac_example_flash.bin
  ILINK.IlinkOutputFile: dmac_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/dmac
    ../../../: dmac.c
  group sam/drivers/dmac/example
    ../../: dmac_example.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: led.c init.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
