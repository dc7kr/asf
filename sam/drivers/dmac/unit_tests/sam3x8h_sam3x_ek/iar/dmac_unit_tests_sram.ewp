# IAR project dmac_unit_tests_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../boards/sam3x_ek; ../..; ../../../../../utils/cmsis/sam3x/source/templates; ../../../../../../common/services/serial; ../../../../../utils/cmsis/sam3x/include; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../..; ../../../../../../common/services/gpio; ../../../../uart; ../../../../../utils; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: dmac_unit_tests_sram.bin
  ILINK.IlinkOutputFile: dmac_unit_tests_sram.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/sam3x_ek
    ../../../../../boards/sam3x_ek/: init.c led.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/dmac
    ../../../: dmac.c
  group sam/drivers/dmac/unit_tests
    ../../: unit_tests.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
