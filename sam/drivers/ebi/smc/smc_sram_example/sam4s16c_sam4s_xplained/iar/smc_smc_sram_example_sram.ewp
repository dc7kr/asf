# IAR project smc_smc_sram_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/sam4s/source/templates; ../../..; ../../../../../uart; ../../../../../../utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../usart; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../../../common/services/ioport; ../../../../../pmc; ../../../../../pio; ../../../../../../boards/sam4s_xplained; ../../../../../../../common/utils; ..; ../../../../../../utils/cmsis/sam4s/include; ../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../common/services/gpio; ../../../../../../../common/services/serial; ../../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: smc_smc_sram_example_sram.bin
  ILINK.IlinkOutputFile: smc_smc_sram_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/ebi/smc
    ../../../: smc.c smc.h
  group sam/drivers/ebi/smc/smc_sram_example
    ../../: smc_sram_example.c
  group sam/drivers/ebi/smc/smc_sram_example/sam4s16c_sam4s_xplained
    ../: conf_uart_serial.h conf_clock.h conf_board.h
  group sam/drivers/ebi/smc/smc_sram_example/sam4s16c_sam4s_xplained/iar
    ./: asf.h
  group sam/drivers/pmc
    ../../../../../pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/uart
    ../../../../../uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../usart/: usart.c usart.h
  group sam/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../utils/cmsis/sam4s/include/: sam4s2b.h sam4s4a.h sam4s16b.h sam4s4c.h sam4sd16c.h sam4s2c.h sam4s8c.h sam4sd32c.h sam4sd16b.h system_sam4s.h sam4sa16b.h sam4s8b.h sam4sd32b.h sam4sa16c.h sam4s.h sam4s16c.h sam4s2a.h sam4s4b.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../utils/cmsis/sam4s/include/pio/: pio_sam4s8c.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4sd16b.h pio_sam4s16b.h pio_sam4sa16b.h pio_sam4s2b.h pio_sam4sa16c.h pio_sam4sd32c.h pio_sam4s8b.h pio_sam4s4b.h pio_sam4s2c.h pio_sam4s16c.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4sd16c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../utils/cmsis/sam4s/include/instance/: instance_uart1.h instance_cmcc.h instance_hsmci.h instance_usart1.h instance_dacc.h instance_matrix.h instance_smc.h instance_wdt.h instance_pmc.h instance_adc.h instance_efc0.h instance_rtc.h instance_spi.h instance_usart0.h instance_supc.h instance_twi0.h instance_udp.h instance_gpbr.h instance_piob.h instance_ssc.h instance_rtt.h instance_pioc.h instance_acc.h instance_tc1.h instance_twi1.h instance_pioa.h instance_pwm.h instance_efc1.h instance_uart0.h instance_tc0.h instance_chipid.h instance_crccu.h instance_rstc.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../utils/cmsis/sam4s/include/component/: component_cmcc.h component_smc.h component_pio.h component_spi.h component_rtc.h component_udp.h component_pdc.h component_adc.h component_twi.h component_hsmci.h component_crccu.h component_supc.h component_efc.h component_acc.h component_wdt.h component_dacc.h component_chipid.h component_pwm.h component_tc.h component_rstc.h component_ssc.h component_gpbr.h component_pmc.h component_usart.h component_uart.h component_matrix.h component_rtt.h
  group sam/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam/boards/sam4s_xplained
    ../../../../../../boards/sam4s_xplained/: init.c led.c sam4s_xplained.h led.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../common/boards/: board.h
