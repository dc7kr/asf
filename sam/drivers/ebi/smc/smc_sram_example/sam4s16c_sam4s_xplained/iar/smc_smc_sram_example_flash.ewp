# IAR project smc_smc_sram_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/sam4s/source/templates; ../../..; ../../../../../uart; ../../../../../../utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../utils/header_files; ../../../../../../../common/boards; ../../../../../../utils/preprocessor; ../../../../../pmc; ../../../../../pio; ../../../../../../boards/sam4s_xplained; ../../../../../../../common/utils; ..; ../../../../../../utils/cmsis/sam4s/include; ../../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  OBJCOPY.OOCOutputFile: smc_smc_sram_example_flash.bin
  ILINK.IlinkOutputFile: smc_smc_sram_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../pio/: pio_handler.c pio.c
  group sam/drivers/ebi/smc
    ../../../: smc.c
  group sam/drivers/ebi/smc/smc_sram_example
    ../../: smc_sram_example.c
  group sam/drivers/uart
    ../../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../../pmc/: pmc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/syscalls/iar
    ../../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam4s_xplained
    ../../../../../../boards/sam4s_xplained/: init.c
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
