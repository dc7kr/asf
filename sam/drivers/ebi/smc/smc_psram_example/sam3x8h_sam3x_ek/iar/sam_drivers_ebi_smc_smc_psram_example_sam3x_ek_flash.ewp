# IAR project sam_drivers_ebi_smc_smc_psram_example_sam3x_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../..; ../../../../../uart; ../../../../../../utils; ../../../../../../../common/services/clock; ../../../../../../boards; ../../../../../../utils/header_files; ../../../../../../../common/boards; ..; ../../../../../../utils/cmsis/sam3x/include; ../../../../../pmc; ../../../../../pio; ../../../../../../boards/sam3x_ek; ../../../../../../../common/services/gpio; ../../../../../../utils/cmsis/sam3x/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_drivers_ebi_smc_smc_psram_example_sam3x_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/syscalls/iar
    ../../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pio
    ../../../../../pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../uart/: uart.c
  group sam/drivers/ebi/smc
    ../../../: smc.c
  group sam/drivers/ebi/smc/smc_psram_example
    ../../: smc_psram_example.c
  group sam/drivers/pmc
    ../../../../../pmc/: pmc.c
  group sam/boards/sam3x_ek
    ../../../../../../boards/sam3x_ek/: init.c
  group common/services/clock/sam3x
    ../../../../../../../common/services/clock/sam3x/: sysclk.c
