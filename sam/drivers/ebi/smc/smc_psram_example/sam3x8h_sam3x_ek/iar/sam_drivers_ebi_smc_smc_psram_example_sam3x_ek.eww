<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_ebi_smc_smc_psram_example_sam3x_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_ebi_smc_smc_psram_example_sam3x_ek_sram.ewp</path>
	</project>
</workspace>
