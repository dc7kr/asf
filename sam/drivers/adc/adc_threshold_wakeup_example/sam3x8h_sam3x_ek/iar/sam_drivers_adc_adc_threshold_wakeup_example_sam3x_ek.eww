<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_adc_adc_threshold_wakeup_example_sam3x_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_adc_adc_threshold_wakeup_example_sam3x_ek_sram.ewp</path>
	</project>
</workspace>
