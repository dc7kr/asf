# IAR project adc_adc_threshold_wakeup_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../..; ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pio; ../../../../../utils/cmsis/sam4s/include; ../../../../../../common/services/serial; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../../common/services/gpio; ../../../../../utils/cmsis/sam4s/source/templates; ../../../../../boards/sam4s_ek2; ../../../../uart; ..; ../../../../../utils; ../../../../tc; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pmc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_adc_threshold_wakeup_example_flash.bin
  ILINK.IlinkOutputFile: adc_adc_threshold_wakeup_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek2
    ../../../../../boards/sam4s_ek2/: init.c led.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/adc
    ../../../: adc.c adc_sam3u.c
  group sam/drivers/adc/adc_threshold_wakeup_example
    ../../: adc_threshold_wakeup_example.c
  group sam/drivers/tc
    ../../../../tc/: tc.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
