# IAR project sam_drivers_adc_adc_temp_sensor_example_sam3s_ek2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../..; ../../../../../utils/header_files; ../../../../uart; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../..; ../../../../../../common/boards; ../../../../../utils/cmsis/sam3s8/source/templates; ../../../../pio; ../../../../../utils/cmsis/sam3s8/include; ../../../../pmc; ..; ../../../../../../common/services/gpio; ../../../../../boards/sam3s_ek2; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_drivers_adc_adc_temp_sensor_example_sam3s_ek2_flash.elf
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: init.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/adc
    ../../../: adc_sam3u.c adc.c
  group sam/drivers/adc/adc_temp_sensor_example
    ../../: adc_temp_sensor_example.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
