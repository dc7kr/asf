<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_adc_adc_temp_sensor_example_sam3s_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_adc_adc_temp_sensor_example_sam3s_ek_sram.ewp</path>
	</project>
</workspace>
