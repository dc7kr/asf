# IAR project sam_drivers_gpbr_unit_tests_sam3n_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM3N_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../pmc; ../../../../efc; ../../../../../../common/services/serial; ../../..; ../../../../../utils/cmsis/sam3n/include; ../../../../../services/flash_efc; ../../../../supc; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards/sam3n_ek; ../../../../../../common/services/gpio; ../../../../uart; ../../../../rtt; ../../../../../utils; ../../../../../utils/cmsis/sam3n/source/templates; ../../../../../utils/header_files; ../../../../../../common/boards; ..; ../../../../pio; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_drivers_gpbr_unit_tests_sam3n_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/services/clock/sam3n
    ../../../../../../common/services/clock/sam3n/: sysclk.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam3n_ek
    ../../../../../boards/sam3n_ek/: init.c
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c
  group sam/drivers/gpbr
    ../../../: gpbr.c
  group sam/drivers/gpbr/unit_tests
    ../../: unit_tests.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/rtt
    ../../../../rtt/: rtt.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/efc
    ../../../../efc/: efc.c
  group sam/drivers/supc
    ../../../../supc/: supc.c
