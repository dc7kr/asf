# IAR project acc_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../adc; ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pmc; ..; ../../../../../../common/services/serial; ../../../../../../common/services/clock; ../../../../../../common/utils; ../../../../../utils/cmsis/sam3s8/source/templates; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards/sam3s_ek2; ../../../../../../common/services/gpio; ../../../../uart; ../../../../../utils; ../../../../dacc; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; ../../..; ../../../../../utils/cmsis/sam3s8/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: acc_example_flash.bin
  ILINK.IlinkOutputFile: acc_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/acc
    ../../../: acc.c
  group sam/drivers/acc/acc_example
    ../../: acc_example.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/adc
    ../../../../adc/: adc.c adc_sam3u.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/dacc
    ../../../../dacc/: dacc.c
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: init.c led.c
