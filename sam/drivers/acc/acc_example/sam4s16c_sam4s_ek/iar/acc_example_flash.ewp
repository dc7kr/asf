# IAR project acc_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/sam4s/source/templates; ../../../../adc; ../../../../../utils/header_files; ../../../../uart; ../../../../../utils; ../../../../dacc; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ..; ../../../../pmc; ../../..; ../../../../pio; ../../../../../boards/sam4s_ek; ../../../../../../common/utils; ../../../../../utils/cmsis/sam4s/include; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  OBJCOPY.OOCOutputFile: acc_example_flash.bin
  ILINK.IlinkOutputFile: acc_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek
    ../../../../../boards/sam4s_ek/: init.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/adc
    ../../../../adc/: adc.c adc_sam3u.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/acc
    ../../../: acc.c
  group sam/drivers/acc/acc_example
    ../../: acc_example.c
  group sam/drivers/dacc
    ../../../../dacc/: dacc.c
