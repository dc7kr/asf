# IAR project acc_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../adc; ../../../../../../common/services/serial; ..; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../utils/cmsis/sam3s/include; ../../../../../../common/utils; ../../../../../utils/cmsis/sam3s/source/templates; ../../../../../boards/sam3s_ek; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/serial/sam_uart; ../../../../uart; ../../../../../utils; ../../../../dacc; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: acc_example_flash.bin
  ILINK.IlinkOutputFile: acc_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/boards/sam3s_ek
    ../../../../../boards/sam3s_ek/: led.c init.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/adc
    ../../../../adc/: adc.c adc_sam3u.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/acc
    ../../../: acc.c
  group sam/drivers/acc/acc_example
    ../../: acc_example.c
  group sam/drivers/dacc
    ../../../../dacc/: dacc.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
