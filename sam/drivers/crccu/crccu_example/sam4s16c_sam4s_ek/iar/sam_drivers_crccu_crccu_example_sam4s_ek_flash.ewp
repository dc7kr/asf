# IAR project sam_drivers_crccu_crccu_example_sam4s_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/sam4s/source/templates; ..; ../../../../uart; ../../../../../utils; ../../../../../../common/services/clock; ../..; ../../../../../boards; ../../../../../utils/header_files; ../../../../../../common/boards; ../../..; ../../../../pio; ../../../../pmc; ../../../../../boards/sam4s_ek; ../../../../../services/flash_efc; ../../../../../utils/cmsis/sam4s/include; ../../../../../../common/services/gpio; ../../../../efc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_drivers_crccu_crccu_example_sam4s_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/drivers/crccu
    ../../../: crccu.c
  group sam/drivers/crccu/crccu_example
    ../../: crccu_example.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/efc
    ../../../../efc/: efc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam4s_ek
    ../../../../../boards/sam4s_ek/: init.c
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
