# IAR project crccu_crccu_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../utils/header_files; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../utils/cmsis/sam4s/include; ../../../../efc; ../../../../../../common/services/serial; ..; ../../../../../services/flash_efc; ../..; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../pio; ../../../../../../common/services/gpio; ../../../../../utils/cmsis/sam4s/source/templates; ../../../../../boards/sam4s_ek2; ../../../../uart; ../../../../../utils; ../../../../usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: crccu_crccu_example_sram.bin
  ILINK.IlinkOutputFile: crccu_crccu_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4sd32/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/crccu
    ../../../: crccu.c
  group sam/drivers/crccu/crccu_example
    ../../: crccu_example.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/efc
    ../../../../efc/: efc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek2
    ../../../../../boards/sam4s_ek2/: init.c led.c
  group sam/services/flash_efc
    ../../../../../services/flash_efc/: flash_efc.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
