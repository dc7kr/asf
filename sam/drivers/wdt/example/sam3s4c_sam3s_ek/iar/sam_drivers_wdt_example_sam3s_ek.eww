<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_wdt_example_sam3s_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_wdt_example_sam3s_ek_sram.ewp</path>
	</project>
</workspace>
