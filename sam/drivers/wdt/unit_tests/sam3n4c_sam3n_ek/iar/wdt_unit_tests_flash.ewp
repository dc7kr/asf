# IAR project wdt_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM3N_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../..; ..; ../../../../uart; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/sam3n/source/templates; ../../../../../utils/cmsis/sam3n/include; ../../../../pio; ../..; ../../../../pmc; ../../../../../boards/sam3n_ek; ../../../../../../common/utils; ../../../../../utils/header_files; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: wdt_unit_tests_flash.bin
  ILINK.IlinkOutputFile: wdt_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam3n
    ../../../../../../common/services/clock/sam3n/: sysclk.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/boards/sam3n_ek
    ../../../../../boards/sam3n_ek/: init.c
  group sam/drivers/wdt
    ../../../: wdt.c
  group sam/drivers/wdt/unit_tests
    ../../: unit_tests.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
