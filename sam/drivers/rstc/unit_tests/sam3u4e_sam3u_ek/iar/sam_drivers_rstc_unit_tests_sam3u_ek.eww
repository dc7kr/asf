<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_rstc_unit_tests_sam3u_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_rstc_unit_tests_sam3u_ek_sram.ewp</path>
	</project>
</workspace>
