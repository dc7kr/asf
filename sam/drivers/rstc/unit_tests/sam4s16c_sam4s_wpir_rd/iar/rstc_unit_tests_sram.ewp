# IAR project rstc_unit_tests_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM4S16C__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4S_WPIR_RD; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..; ../../..; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../utils/cmsis/sam4s/include; ../../../../../boards/sam4s_wpir_rd; ../..; ../../../../../../common/services/serial; ../../../../gpbr; ../../../../../../common/utils; ../../../../wdt; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/serial/sam_uart; ../../../../../utils/cmsis/sam4s/source/templates; ../../../../uart; ../../../../../utils; ../../../../usart; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rstc_unit_tests_sram.bin
  ILINK.IlinkOutputFile: rstc_unit_tests_sram.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/gpbr
    ../../../../gpbr/: gpbr.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/rstc
    ../../../: rstc.c
  group sam/drivers/rstc/unit_tests
    ../../: unit_tests.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/wdt
    ../../../../wdt/: wdt.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_wpir_rd
    ../../../../../boards/sam4s_wpir_rd/: init.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
