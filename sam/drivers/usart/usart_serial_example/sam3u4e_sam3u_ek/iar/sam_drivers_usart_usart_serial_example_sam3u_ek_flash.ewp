# IAR project sam_drivers_usart_usart_serial_example_sam3u_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../uart; ../../../../../utils/cmsis/sam3u/source/templates; ..; ../../../../../../common/services/clock; ../..; ../../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../boards/sam3u_ek; ../../../../../utils/cmsis/sam3u/include; ../../../../pmc; ../../../../pio; ../../../../tc; ../../../../pdc; ../../../../../../common/services/gpio; ../../../../../utils; ../../../../../boards; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; BOARD=SAM3U_EK
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_drivers_usart_usart_serial_example_sam3u_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  OBJCOPY.OOCOutputFile: output.bin
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: init.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c
  group sam/drivers/usart
    ../../../: usart.c
  group sam/drivers/usart/usart_serial_example
    ../../: usart_serial_example.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/tc
    ../../../../tc/: tc.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c
