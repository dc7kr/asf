<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_usart_usart_hard_handshaking_example_sam3s_ek2_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_usart_usart_hard_handshaking_example_sam3s_ek2_sram.ewp</path>
	</project>
</workspace>
