# IAR project sam_drivers_usart_usart_hard_handshaking_example_sam3n_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../uart; ..; ../../../../../utils; ../../../../../../common/services/clock; ../../../../tc; ../../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils/cmsis/sam3n/source/templates; ../../../../../utils/cmsis/sam3n/include; ../../../../pmc; ../../../../pio; ../../../../../boards/sam3n_ek; ../../../../../boards; ../../../../pdc; ../..; ../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_drivers_usart_usart_hard_handshaking_example_sam3n_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/sam3n_ek
    ../../../../../boards/sam3n_ek/: init.c
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/tc
    ../../../../tc/: tc.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group sam/drivers/usart
    ../../../: usart.c
  group sam/drivers/usart/usart_hard_handshaking_example
    ../../: usart_hard_handshaking_example.c
  group common/services/clock/sam3n
    ../../../../../../common/services/clock/sam3n/: sysclk.c
