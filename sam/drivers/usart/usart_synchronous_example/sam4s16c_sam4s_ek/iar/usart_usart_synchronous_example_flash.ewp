# IAR project usart_usart_synchronous_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../utils/preprocessor; ../../../../pmc; ../../../../../utils/cmsis/sam4s/include; ../../../../../../common/services/serial; ..; ../../../../pdc; ../../../../../../common/utils; ../..; ../../../../../boards/sam4s_ek; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../utils/cmsis/sam4s/source/templates; ../../../../uart; ../../../../../utils; ../../../../tc; ../../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_usart_synchronous_example_flash.bin
  ILINK.IlinkOutputFile: usart_usart_synchronous_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/usart
    ../../../: usart.c
  group sam/drivers/usart/usart_synchronous_example
    ../../: usart_synchronous_example.c
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/tc
    ../../../../tc/: tc.c
  group sam/drivers/pmc
    ../../../../pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek
    ../../../../../boards/sam4s_ek/: init.c led.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c
