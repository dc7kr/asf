# IAR project usart_usart_synchronous_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ..; ../..; ../../../../uart; ../../../../../utils; ../../../../../../common/services/clock; ../../../../tc; ../../..; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/sam3s8/source/templates; ../../../../pmc; ../../../../pio; ../../../../../utils/cmsis/sam3s8/include; ../../../../../boards; ../../../../pdc; ../../../../../../common/utils; ../../../../../boards/sam3s_ek2; ../../../../../../common/services/gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  OBJCOPY.OOCOutputFile: usart_usart_synchronous_example_sram.bin
  ILINK.IlinkOutputFile: usart_usart_synchronous_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3sd8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/tc
    ../../../../tc/: tc.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/usart
    ../../../: usart.c
  group sam/drivers/usart/usart_synchronous_example
    ../../: usart_synchronous_example.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: init.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
