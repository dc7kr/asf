# IAR project bpm_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4L_EK; ARM_MATH_CM4=true; __ATSAM4LC4C__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/sam4l/source/templates; ../../../../../../common/services/serial; ../../../../../utils; ../../../../../../common/services/clock; ..; ../../../../usart; ../../../../../../common/utils/stdio/stdio_serial; ../../../../flashcalw; ../../../../../utils/preprocessor; ../../../../../../common/boards; ../../../../../boards/sam4l_ek; ../../../../../../common/services/ioport; ../../../../../boards; ../../..; ../../../../../../common/utils; ../../../../../utils/header_files; ../..; ../../../../../utils/cmsis/sam4l/include; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: bpm_unit_tests_flash.bin
  ILINK.IlinkOutputFile: bpm_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../utils/cmsis/sam4l/source/templates/: exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/drivers/bpm
    ../../../: bpm.c
  group sam/drivers/bpm/unit_tests
    ../../: unit_tests.c ast.c
  group sam/drivers/flashcalw
    ../../../../flashcalw/: flashcalw.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/boards/sam4l_ek
    ../../../../../boards/sam4l_ek/: init.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: osc.c sysclk.c dfll.c pll.c
