# IAR project sam_drivers_spi_unit_tests_sam3s_ek2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3SD8C__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../..; ../../../../uart; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils/cmsis/sam3s8/source/templates; ../../../../pmc; ../../../../pio; ../../..; ../../../../../utils/cmsis/sam3s8/include; ../../../../../boards/sam3s_ek2; ../../../../../../common/utils; ..; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_drivers_spi_unit_tests_sam3s_ek2_flash.elf
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/services/clock/sam3s
    ../../../../../../common/services/clock/sam3s/: sysclk.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../utils/cmsis/sam3s8/source/templates/: system_sam3sd8.c exceptions.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/spi
    ../../../: spi.c
  group sam/drivers/spi/unit_tests
    ../../: unit_tests.c
  group sam/boards/sam3s_ek2
    ../../../../../boards/sam3s_ek2/: init.c
