# IAR project eic_eic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; ARM_MATH_CM4=true; __ATSAM4LC4C__
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/sam4l/source/templates; ../../../../../../common/services/serial; ../../../../../boards/sam4l_ek; ../../../../../utils; ../../../../../../common/services/clock; ../../../../flashcalw; ../../../../usart; ../../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../utils/preprocessor; ../../../../../../common/boards; ../../../../bpm; ../..; ../../../../../../common/services/ioport; ../../..; ../../../../../boards; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../utils/header_files; ../../../../../utils/cmsis/sam4l/include; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; ARM_MATH_CM4=true; __ATSAM4LC4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: eic_eic_example_flash.bin
  ILINK.IlinkOutputFile: eic_eic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/eic
    ../../../: eic.c
  group sam/drivers/eic/example
    ../../: eic_example.c
  group sam/drivers/flashcalw
    ../../../../flashcalw/: flashcalw.c
  group sam/drivers/usart
    ../../../../usart/: usart.c
  group sam/drivers/bpm
    ../../../../bpm/: bpm.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../utils/cmsis/sam4l/source/templates/: exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_ek
    ../../../../../boards/sam4l_ek/: init.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4l
    ../../../../../../common/services/clock/sam4l/: osc.c pll.c sysclk.c dfll.c
  group common/services/sleepmgr/sam4l
    ../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c
