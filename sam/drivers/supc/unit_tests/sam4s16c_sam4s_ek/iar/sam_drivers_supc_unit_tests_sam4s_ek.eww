<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_supc_unit_tests_sam4s_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_supc_unit_tests_sam4s_ek_sram.ewp</path>
	</project>
</workspace>
