<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\flashcalw_example_flash.ewp</path>
	</project>
</workspace>
