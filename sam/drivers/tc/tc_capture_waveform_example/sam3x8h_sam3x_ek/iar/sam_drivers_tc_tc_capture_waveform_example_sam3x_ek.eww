<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_tc_tc_capture_waveform_example_sam3x_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_tc_tc_capture_waveform_example_sam3x_ek_sram.ewp</path>
	</project>
</workspace>
