# IAR project sam_drivers_pwm_unit_tests_sam3u_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3U4E__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ..; ../../../../../utils/header_files; ../../../../uart; ../../../../../utils/cmsis/sam3u/source/templates; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../..; ../../..; ../../../../../utils/cmsis/sam3u/include; ../../../../pio; ../../../../pmc; ../../../../pdc; ../../../../../../common/utils; ../../../../../boards/sam3u_ek; ../../../../../../common/services/gpio; ../../../../../../common/services/serial; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: sam_drivers_pwm_unit_tests_sam3u_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  OBJCOPY.OOCOutputFile: output.bin
  group sam/drivers/pwm
    ../../../: pwm.c
  group sam/drivers/pwm/unit_tests
    ../../: unit_tests.c
  group sam/drivers/pdc
    ../../../../pdc/: pdc.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pio
    ../../../../pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/boards/sam3u_ek
    ../../../../../boards/sam3u_ek/: init.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group common/services/clock/sam3u
    ../../../../../../common/services/clock/sam3u/: sysclk.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
