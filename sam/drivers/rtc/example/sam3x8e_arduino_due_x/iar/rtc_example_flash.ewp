# IAR project rtc_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../uart; ../../../../../boards/arduino_due_x; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../utils/header_files; ../../../../../../common/boards; ../../../../../utils/preprocessor; ../../../../../utils/cmsis/sam3x/include; ../../..; ../../../../pmc; ..; ../../../../pio; ../../../../../../common/utils; ../../../../../../common/services/gpio; ../../../../../utils/cmsis/sam3x/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  OBJCOPY.OOCOutputFile: rtc_example_flash.bin
  ILINK.IlinkOutputFile: rtc_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/syscalls/iar
    ../../../../../utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/arduino_due_x
    ../../../../../boards/arduino_due_x/: init.c
  group sam/drivers/rtc
    ../../../: rtc.c
  group sam/drivers/rtc/example
    ../../: rtc_example.c
  group sam/drivers/uart
    ../../../../uart/: uart.c
  group sam/drivers/pmc
    ../../../../pmc/: pmc.c
  group sam/drivers/pio
    ../../../../pio/: pio_handler.c pio.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c
