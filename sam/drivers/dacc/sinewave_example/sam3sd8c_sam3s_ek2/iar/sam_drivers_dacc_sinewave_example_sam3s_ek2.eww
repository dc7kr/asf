<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam_drivers_dacc_sinewave_example_sam3s_ek2_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\sam_drivers_dacc_sinewave_example_sam3s_ek2_sram.ewp</path>
	</project>
</workspace>
