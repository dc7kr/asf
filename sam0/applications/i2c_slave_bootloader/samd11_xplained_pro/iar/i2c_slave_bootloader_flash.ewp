# IAR project i2c_slave_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; I2C_SLAVE_CALLBACK_MODE=false; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__; WDT_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../drivers/system/power; ../../../../drivers/system/reset; ../../../../../common/boards; ../../../../utils/preprocessor; ../../../../utils; ../../../../boards/samd11_xplained_pro; ../../../../drivers/nvm; ../../../../drivers/sercom; ../../../../drivers/port; ../../../../boards; ../../../../drivers/system/reset/reset_sam_d_r; ../../../../drivers/wdt; ../../../../drivers/sercom/i2c; ../../../../../common/utils; ../../../../utils/cmsis/samd11/source; ../../../../drivers/system/interrupt; ../../../../drivers/system/clock/clock_samd10_d11; ../../../../drivers/system/power/power_sam_d_r; ../../../../drivers/system/interrupt/system_interrupt_samd10_d11; ../../../../utils/cmsis/samd11/include; ../..; ../../../../drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21; ..; ../../../../drivers/system/pinmux; ../../../../drivers/system; ../../../../utils/header_files; ../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2c_slave_bootloader_flash.bin
  ILINK.IlinkOutputFile: i2c_slave_bootloader_flash.out
  ILINK.IlinkIcfFile: ../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../drivers/sercom/: sercom.c sercom.h sercom_pinout.h
  group sam0/drivers/sercom/i2c
    ../../../../drivers/sercom/i2c/: i2c_slave.h i2c_common.h
  group sam0/drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21
    ../../../../drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21/: i2c_slave.c
  group sam0/drivers/sercom/i2c/quick_start_slave
    ../../../../drivers/sercom/i2c/quick_start_slave/: qs_i2c_slave_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_slave_dma
    ../../../../drivers/sercom/i2c/quick_start_slave_dma/: qs_i2c_slave_dma.h
  group sam0/drivers/port
    ../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../../drivers/system/clock/clock_samd10_d11/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../drivers/system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/wdt
    ../../../../drivers/wdt/: wdt_callback.c wdt.c wdt_callback.h wdt.h
  group sam0/drivers/wdt/quick_start
    ../../../../drivers/wdt/quick_start/: qs_wdt_basic.h
  group sam0/drivers/wdt/quick_start_callback
    ../../../../drivers/wdt/quick_start_callback/: qs_wdt_callback.h
  group sam0/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/boards/samd11_xplained_pro
    ../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group sam0/utils
    ../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd11/source
    ../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../utils/cmsis/samd11/include/: samd11d14as.h samd11d14am.h samd11c14a.h samd11.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../utils/cmsis/samd11/include/component/: adc.h gclk.h ac.h nvmctrl.h dsu.h wdt.h tcc.h dac.h mtb.h tc.h sercom.h hmatrixb.h evsys.h pac.h sysctrl.h pm.h eic.h dmac.h port.h usb.h rtc.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../utils/cmsis/samd11/include/instance/: sercom1.h nvmctrl.h wdt.h dsu.h pac1.h pac2.h dmac.h evsys.h gclk.h dac.h sbmatrix.h adc.h tcc0.h pac0.h tc2.h ac.h usb.h sysctrl.h sercom0.h sercom2.h port.h tc1.h rtc.h mtb.h pm.h eic.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../utils/cmsis/samd11/include/pio/: samd11d14am.h samd11d14as.h samd11c14a.h
  group sam0/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../utils/preprocessor/: mrecursion.h stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam0/applications/i2c_slave_bootloader
    ../../: i2c_slave_bootloader.c
  group sam0/applications/i2c_slave_bootloader/samd11_xplained_pro
    ../: conf_board.h conf_bootloader.h conf_clocks.h
  group sam0/applications/i2c_slave_bootloader/samd11_xplained_pro/iar
    ./: asf.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
