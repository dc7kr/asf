# IAR project rww_eeprom_emulator_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../drivers/system/power; ../../../../../../../drivers/bod; ../../../../../../../drivers/system/reset; ../../../../../../../drivers/system/interrupt/system_interrupt_saml21; ../../../../../../../utils/preprocessor; ../../..; ../../../../../../../utils; ../../../../../../../drivers/nvm; ../../../../../../../drivers/port; ../../../../../../../boards; ../../../../../../../../common/utils; ../../../../../../../drivers/system/interrupt; ../../../../../../../drivers/system/power/power_sam_l; ../../../../../../../utils/header_files; ../../../../../../../boards/saml21_xplained_pro; ..; ../..; ../../../../../../../utils/cmsis/saml21/include; ../../../../../../../drivers/system/clock/clock_saml21; ../../../../../../../../common/boards; ../../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../../drivers/system/pinmux; ../../../../../../../drivers/system; ../../../../../../../utils/cmsis/saml21/source; ../../../../../../../drivers/bod/bod_sam_l; ../../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM0=true; __SAML21J18A__; BOARD=SAML21_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: rww_eeprom_emulator_quick_start_flash.bin
  ILINK.IlinkOutputFile: rww_eeprom_emulator_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/bod
    ../../../../../../../drivers/bod/: bod.h
  group sam0/drivers/bod/bod_sam_l
    ../../../../../../../drivers/bod/bod_sam_l/: bod.c bod_feature.h
  group sam0/drivers/system
    ../../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../drivers/system/clock/clock_saml21/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/port
    ../../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/nvm
    ../../../../../../../drivers/nvm/: nvm.c nvm.h
  group sam0/drivers/nvm/quick_start_basic
    ../../../../../../../drivers/nvm/quick_start_basic/: qs_nvm_basic.h
  group sam0/services/eeprom/emulator/rwwee_array
    ../../../: rww_eeprom.c rww_eeprom.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start
    ../../: qs_emulator_basic.c qs_emulator_basic.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/saml21_xplained_pro
    ../: conf_board.h conf_rwwee.h conf_clocks.h
  group sam0/services/eeprom/emulator/rwwee_array/quick_start/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/utils
    ../../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../../utils/cmsis/saml21/include/: saml21g17a.h saml21.h saml21e17a.h saml21j18a.h saml21j17a.h saml21e16a.h saml21j16a.h saml21g16a.h saml21g18a.h saml21e15a.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../../utils/cmsis/saml21/include/pio/: saml21g16a.h saml21e17a.h saml21j16a.h saml21g18a.h saml21j18a.h saml21j17a.h saml21g17a.h saml21e15a.h saml21e16a.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../../utils/cmsis/saml21/include/instance/: ccl.h ac.h trng.h pac.h eic.h supc.h dmac.h rtc.h adc.h tcc1.h dsu.h pm.h nvmctrl.h tc2.h evsys.h wdt.h sercom0.h tc0.h oscctrl.h sercom4.h osc32kctrl.h rstc.h tc4.h tcc0.h opamp.h usb.h sercom2.h tc3.h gclk.h tc1.h sercom1.h tcc2.h sercom3.h sercom5.h port.h mtb.h tal.h aes.h dac.h mclk.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../../utils/cmsis/saml21/include/component/: pac.h eic.h evsys.h mclk.h nvmctrl.h mtb.h adc.h aes.h tc.h tal.h port.h dsu.h opamp.h osc32kctrl.h sercom.h rstc.h supc.h pm.h rtc.h usb.h dac.h gclk.h wdt.h ccl.h tcc.h ac.h dmac.h trng.h oscctrl.h
  group sam0/utils/preprocessor
    ../../../../../../../utils/preprocessor/: mrecursion.h tpaste.h preprocessor.h mrepeat.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
