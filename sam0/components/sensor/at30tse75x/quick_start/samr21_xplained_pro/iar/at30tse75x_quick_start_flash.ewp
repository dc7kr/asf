# IAR project at30tse75x_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR21G18A Atmel ATSAMR21G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAMR21_XPLAINED_PRO; __SAMR21G18A__; I2C_MASTER_CALLBACK_MODE=false
  ICCARM.CCIncludePath2: ../../../../../../drivers/system/clock/clock_samd21_r21; ../../../../../../drivers/port; ../../../../../../drivers/system/reset; ../../../../../../drivers/system/interrupt/system_interrupt_samr21; ../../../../../../utils/preprocessor; ../../../../../../utils/cmsis/samr21/source; ../../../../../../utils; ../../../../../../drivers/sercom; ../../../../../../drivers/system/power; ../../../../../../boards; ../../../../../../drivers/sercom/i2c; ../../../../../../../common/utils; ../../../../../../drivers/system/interrupt; ../../../../../../drivers/system/power/power_sam_d_r; ../../../../../../drivers/system/reset/reset_sam_d_r; ../..; ../../..; ../../../../../../boards/samr21_xplained_pro; ../../../../../../utils/cmsis/samr21/include; ../../../../../../drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21; ../../../../../../../common/boards; ../../../../../../drivers/system/pinmux; ../../../../../../drivers/system; ..; ../../../../../../utils/header_files; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_quick_start_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samr21/iar/samr21g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr21/source
    ../../../../../../utils/cmsis/samr21/source/: system_samr21.c system_samr21.h
  group sam0/utils/cmsis/samr21/source/iar
    ../../../../../../utils/cmsis/samr21/source/iar/: startup_samr21.c
  group sam0/utils/cmsis/samr21/include
    ../../../../../../utils/cmsis/samr21/include/: samr21e18a.h samr21.h samr21g17a.h samr21g16a.h samr21e16a.h samr21e17a.h samr21g18a.h
  group sam0/utils/cmsis/samr21/include/component
    ../../../../../../utils/cmsis/samr21/include/component/: mtb.h sysctrl.h hmatrixb.h sercom.h wdt.h ac.h dsu.h dmac.h pm.h pac.h adc.h gclk.h nvmctrl.h eic.h port.h rfctrl.h rtc.h usb.h tcc.h tc.h evsys.h
  group sam0/utils/cmsis/samr21/include/instance
    ../../../../../../utils/cmsis/samr21/include/instance/: pac2.h sercom5.h sercom3.h tc3.h adc.h mtb.h dsu.h pm.h rtc.h sercom1.h sercom4.h tc5.h eic.h evsys.h nvmctrl.h usb.h tc4.h sysctrl.h sercom2.h gclk.h dmac.h sercom0.h pac0.h tcc1.h tcc2.h tcc0.h rfctrl.h port.h wdt.h sbmatrix.h pac1.h ac.h
  group sam0/utils/cmsis/samr21/include/pio
    ../../../../../../utils/cmsis/samr21/include/pio/: samr21g18a.h samr21g16a.h samr21e17a.h samr21g17a.h samr21e16a.h samr21e18a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: mrecursion.h stringz.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr21
    ../../../../../../drivers/system/interrupt/system_interrupt_samr21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21
    ../../../../../../drivers/system/clock/clock_samd21_r21/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_d_r
    ../../../../../../drivers/system/power/power_sam_d_r/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r
    ../../../../../../drivers/system/reset/reset_sam_d_r/: reset.h
  group sam0/drivers/sercom
    ../../../../../../drivers/sercom/: sercom.c sercom_pinout.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../../../../drivers/sercom/i2c/: i2c_master.h i2c_common.h
  group sam0/drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21
    ../../../../../../drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/components/sensor/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start
    ../../: qs_at30tse75x.c qs_at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start/samr21_xplained_pro
    ../: conf_board.h conf_at30tse75x.h conf_clocks.h
  group sam0/components/sensor/at30tse75x/quick_start/samr21_xplained_pro/iar
    ./: asf.h
  group sam0/boards/samr21_xplained_pro
    ../../../../../../boards/samr21_xplained_pro/: board_init.c samr21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
