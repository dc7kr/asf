# IAR project at30tse75x_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18A Atmel ATSAML21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; __SAML21J18A__; I2C_MASTER_CALLBACK_MODE=false; BOARD=SAML21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../drivers/system/power; ../../../../../../drivers/system/reset; ../../../../../../boards/saml21_xplained_pro; ..; ../../../../../../utils/preprocessor; ../../../../../../utils; ../../../../../../drivers/sercom; ../../../../../../drivers/port; ../../../../../../boards; ../../../../../../drivers/sercom/i2c; ../../../../../../../common/utils; ../../../../../../drivers/system/interrupt; ../../../../../../drivers/system/power/power_sam_l; ../../../../../../utils/header_files; ../../../../../../drivers/system/interrupt/system_interrupt_saml21; ../..; ../../..; ../../../../../../drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21; ../../../../../../utils/cmsis/saml21/include; ../../../../../../drivers/system/clock/clock_saml21; ../../../../../../../common/boards; ../../../../../../drivers/system/reset/reset_sam_l; ../../../../../../drivers/system/pinmux; ../../../../../../drivers/system; ../../../../../../utils/cmsis/saml21/source; ../../../../../../drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at30tse75x_quick_start_flash.bin
  ILINK.IlinkOutputFile: at30tse75x_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/saml21/iar/saml21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../drivers/system/clock/clock_saml21/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/sercom
    ../../../../../../drivers/sercom/: sercom.c sercom_pinout.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../../../../drivers/sercom/i2c/: i2c_master.h i2c_common.h
  group sam0/drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21
    ../../../../../../drivers/sercom/i2c/i2c_samd21_r21_d10_d11_l21/: i2c_master.c
  group sam0/drivers/sercom/i2c/quick_start_master
    ../../../../../../drivers/sercom/i2c/quick_start_master/: qs_i2c_master_basic_use.h
  group sam0/drivers/sercom/i2c/quick_start_master_dma
    ../../../../../../drivers/sercom/i2c/quick_start_master_dma/: qs_i2c_master_dma.h
  group sam0/drivers/port
    ../../../../../../drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../drivers/port/quick_start/: qs_port_basic.h
  group sam0/boards/saml21_xplained_pro
    ../../../../../../boards/saml21_xplained_pro/: board_init.c saml21_xplained_pro.h
  group sam0/components/sensor/at30tse75x
    ../../../: at30tse75x.c at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start
    ../../: qs_at30tse75x.c qs_at30tse75x.h
  group sam0/components/sensor/at30tse75x/quick_start/saml21_xplained_pro
    ../: conf_board.h conf_at30tse75x.h conf_clocks.h
  group sam0/components/sensor/at30tse75x/quick_start/saml21_xplained_pro/iar
    ./: asf.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include
    ../../../../../../utils/cmsis/saml21/include/: saml21e16a.h saml21g16a.h saml21e15a.h saml21e17a.h saml21.h saml21j17a.h saml21j18a.h saml21g17a.h saml21g18a.h saml21j16a.h
  group sam0/utils/cmsis/saml21/include/instance
    ../../../../../../utils/cmsis/saml21/include/instance/: tcc0.h pac.h tcc2.h tc3.h tal.h wdt.h evsys.h tc0.h nvmctrl.h sercom0.h dmac.h tcc1.h osc32kctrl.h tc2.h tc4.h mtb.h sercom2.h ac.h adc.h sercom5.h port.h supc.h pm.h rtc.h usb.h oscctrl.h mclk.h aes.h sercom4.h ccl.h gclk.h dac.h dsu.h tc1.h rstc.h opamp.h trng.h eic.h sercom1.h sercom3.h
  group sam0/utils/cmsis/saml21/include/component
    ../../../../../../utils/cmsis/saml21/include/component/: ac.h dac.h evsys.h adc.h pac.h wdt.h nvmctrl.h dsu.h dmac.h sercom.h osc32kctrl.h rstc.h eic.h supc.h rtc.h mtb.h trng.h gclk.h opamp.h aes.h pm.h tc.h tal.h ccl.h mclk.h port.h tcc.h oscctrl.h usb.h
  group sam0/utils/cmsis/saml21/include/pio
    ../../../../../../utils/cmsis/saml21/include/pio/: saml21e17a.h saml21j18a.h saml21e16a.h saml21g18a.h saml21g17a.h saml21j17a.h saml21g16a.h saml21e15a.h saml21j16a.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
