# IAR project usart_quick_start_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD11D14AM Atmel ATSAMD11D14AM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; USART_CALLBACK_MODE=false; BOARD=SAMD11_XPLAINED_PRO; __SAMD11D14AM__
  ICCARM.CCIncludePath2: ../../../../../system/interrupt; ../../../../../system/clock/clock_samd10_d11; ../../../../../../utils; ../../../..; ../../../../../port; ../../../../../../boards; ../../..; ../../../../../../../common/boards; ../../../../../system; ../../../../../system/pinmux; ../../../../../system/interrupt/system_interrupt_samd10_d11; ../../../../../../utils/preprocessor; ..; ../../../../../../utils/cmsis/samd11/include; ../../../../../../utils/header_files; ../../../../../../../common/utils; ../../../../../system/clock; ../../../../../../utils/cmsis/samd11/source; ../../../../../../boards/samd11_xplained_pro; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: usart_quick_start_flash.bin
  ILINK.IlinkOutputFile: usart_quick_start_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd11/iar/samd11d14am_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start
    ../../: qs_usart_basic_use.c qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start/samd11_xplained_pro
    ../: conf_board.h conf_clocks.h
  group sam0/drivers/sercom/usart/quick_start/samd11_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd10_d11
    ../../../../../system/clock/clock_samd10_d11/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd10_d11
    ../../../../../system/interrupt/system_interrupt_samd10_d11/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd11/source
    ../../../../../../utils/cmsis/samd11/source/: system_samd11.c system_samd11.h
  group sam0/utils/cmsis/samd11/source/iar
    ../../../../../../utils/cmsis/samd11/source/iar/: startup_samd11.c
  group sam0/utils/cmsis/samd11/include
    ../../../../../../utils/cmsis/samd11/include/: samd11d14am.h samd11d14as.h samd11c14a.h samd11.h
  group sam0/utils/cmsis/samd11/include/component
    ../../../../../../utils/cmsis/samd11/include/component/: nvmctrl.h ac.h dmac.h mtb.h usb.h dsu.h sercom.h tc.h dac.h rtc.h sysctrl.h wdt.h pac.h adc.h evsys.h tcc.h port.h eic.h gclk.h pm.h
  group sam0/utils/cmsis/samd11/include/pio
    ../../../../../../utils/cmsis/samd11/include/pio/: samd11d14am.h samd11c14a.h samd11d14as.h
  group sam0/utils/cmsis/samd11/include/instance
    ../../../../../../utils/cmsis/samd11/include/instance/: dmac.h nvmctrl.h evsys.h dac.h sercom2.h gclk.h sercom1.h sercom0.h ac.h pm.h usb.h tc1.h mtb.h sysctrl.h tc2.h eic.h port.h pac2.h dsu.h rtc.h pac1.h wdt.h pac0.h tcc0.h adc.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: tpaste.h mrepeat.h mrecursion.h stringz.h preprocessor.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samd11_xplained_pro
    ../../../../../../boards/samd11_xplained_pro/: board_init.c samd11_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
