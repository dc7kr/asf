# IAR project i2c_quick_start_i2c_slave_dma_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; __SAMD21J18A__; I2C_SLAVE_CALLBACK_MODE=false; BOARD=SAMD21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../utils/cmsis/samd21/source; ../../../../../system/interrupt; ../../../../../system/clock/clock_samd21; ../../../../../port; ../../../../../../utils/preprocessor; ../../../../../dma; ../../../../../../utils; ../../../../../../utils/cmsis/samd21/include/component; ../../../..; ../../../../../../boards; ../../..; ../../../../../../../common/utils; ../../../../../system/interrupt/system_interrupt_samd21; ../../../../../../utils/cmsis/samd21/include; ../..; ../../../i2c_samd21; ../../../../../../utils/cmsis/samd21/include/pio; ../../../../../../utils/cmsis/samd21/include/instance; ..; ../../../../../../../common/boards; ../../../../../system/pinmux; ../../../../../system; ../../../../../../utils/header_files; ../../../../../../boards/samd21_xplained_pro; ../../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: i2c_quick_start_i2c_slave_dma_flash.bin
  ILINK.IlinkOutputFile: i2c_quick_start_i2c_slave_dma_flash.out
  ILINK.IlinkIcfFile: ../../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/clock
    ../../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21
    ../../../../../system/clock/clock_samd21/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/pinmux
    ../../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/sercom
    ../../../../: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/i2c
    ../../../: i2c_common.h i2c_slave.h
  group sam0/drivers/sercom/i2c/i2c_samd21
    ../../../i2c_samd21/: i2c_slave.c
  group sam0/drivers/sercom/i2c/quick_start_slave_dma
    ../../: qs_i2c_slave_dma.c qs_i2c_slave_dma.h
  group sam0/drivers/sercom/i2c/quick_start_slave_dma/samd21_xplained_pro
    ../: conf_board.h conf_dma.h conf_clocks.h
  group sam0/drivers/sercom/i2c/quick_start_slave_dma/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/sercom/i2c/quick_start_slave
    ../../../quick_start_slave/: qs_i2c_slave_basic_use.h
  group sam0/drivers/dma
    ../../../../../dma/: dma.c dma.h dma_crc.h
  group sam0/drivers/dma/quick_start
    ../../../../../dma/quick_start/: qs_dma_basic.h
  group sam0/drivers/port
    ../../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../utils/cmsis/samd21/include/: samd21e15a.h samd21.h samd21e17a.h samd21j16a.h samd21j17a.h samd21g16a.h samd21g18a.h samd21e18a.h samd21e16a.h samd21j18a.h samd21g17a.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../utils/cmsis/samd21/include/pio/: pio_samd21j18a.h pio_samd21e18a.h pio_samd21e15a.h pio_samd21g18a.h pio_samd21e16a.h pio_samd21g16a.h pio_samd21g17a.h pio_samd21j16a.h pio_samd21j17a.h pio_samd21e17a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../utils/cmsis/samd21/include/component/: component_ac.h component_gclk.h component_tcc.h component_rtc.h component_adc.h component_dmac.h component_mtb.h component_tc.h component_pac.h component_eic.h component_usb.h component_port.h component_sercom.h component_sysctrl.h component_i2s.h component_wdt.h component_pm.h component_dac.h component_dsu.h component_evsys.h component_nvmctrl.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../utils/cmsis/samd21/include/instance/: instance_adc.h instance_rtc.h instance_pac1.h instance_pm.h instance_tc7.h instance_sercom5.h instance_sercom2.h instance_tc4.h instance_evsys.h instance_dac.h instance_ac.h instance_tc6.h instance_gclk.h instance_tcc2.h instance_tcc0.h instance_pac2.h instance_port.h instance_sercom4.h instance_sercom0.h instance_dmac.h instance_sercom3.h instance_tcc1.h instance_i2s.h instance_dsu.h instance_pac0.h instance_wdt.h instance_eic.h instance_mtb.h instance_usb.h instance_sysctrl.h instance_nvmctrl.h instance_tc5.h instance_sercom1.h instance_tc3.h
  group sam0/utils/preprocessor
    ../../../../../../utils/preprocessor/: stringz.h mrecursion.h tpaste.h preprocessor.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../../utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
