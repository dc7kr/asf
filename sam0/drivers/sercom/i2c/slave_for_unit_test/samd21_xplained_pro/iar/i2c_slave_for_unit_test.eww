<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\i2c_slave_for_unit_test_flash.ewp</path>
	</project>
</workspace>
