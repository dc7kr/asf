# IAR project adc_quick_start_dma_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ADC_CALLBACK_MODE=false; ARM_MATH_CM0=true; __SAMD21J18A__; DAC_CALLBACK_MODE=true; BOARD=SAMD21_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../utils/cmsis/samd21/source; ../../../../system/interrupt; ../..; ../../../../port; ../../../../../../common/boards; ../../../../system/clock/clock_samd21; ../../../../../utils/preprocessor; ../../../../dma; ../../../../../utils; ../../../../../utils/cmsis/samd21/include/component; ../../../../../boards; ../../../../../../common/utils; ../../../../../boards/samd21_xplained_pro; ../../../../../utils/cmsis/samd21/include; ../../../../dac; ../../../../system/interrupt/system_interrupt_samd21; ../../../../../utils/cmsis/samd21/include/pio; ../../../../../utils/cmsis/samd21/include/instance; ../../..; ../../../../system/pinmux; ../../../../system; ../../../../../utils/header_files; ..; ../../../../system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: adc_quick_start_dma_flash.bin
  ILINK.IlinkOutputFile: adc_quick_start_dma_flash.out
  ILINK.IlinkIcfFile: ../../../../../utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21
    ../../../../system/clock/clock_samd21/: clock.c gclk.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/pinmux
    ../../../../system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/interrupt
    ../../../../system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/dac
    ../../../../dac/: dac.c dac_callback.c dac.h dac_callback.h
  group sam0/drivers/dac/quick_start_callback
    ../../../../dac/quick_start_callback/: qs_dac_callback.h
  group sam0/drivers/dac/quick_start
    ../../../../dac/quick_start/: qs_dac_basic.h
  group sam0/drivers/adc
    ../../../: adc.c adc.h
  group sam0/drivers/adc/quick_start_dma
    ../../: qs_adc_dma_use.c qs_adc_dma_use.h
  group sam0/drivers/adc/quick_start_dma/samd21_xplained_pro
    ../: conf_board.h conf_dma.h conf_clocks.h
  group sam0/drivers/adc/quick_start_dma/samd21_xplained_pro/iar
    ./: asf.h
  group sam0/drivers/adc/quick_start
    ../../../quick_start/: qs_adc_basic.h
  group sam0/drivers/port
    ../../../../port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../port/quick_start/: qs_port_basic.h
  group sam0/drivers/dma
    ../../../../dma/: dma.c dma_crc.h dma.h
  group sam0/drivers/dma/quick_start
    ../../../../dma/quick_start/: qs_dma_basic.h
  group sam0/utils
    ../../../../../utils/: status_codes.h compiler.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../utils/cmsis/samd21/include/: samd21e15a.h samd21g17a.h samd21e16a.h samd21g16a.h samd21e18a.h samd21g18a.h samd21j18a.h samd21e17a.h samd21j16a.h samd21.h samd21j17a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../utils/cmsis/samd21/include/component/: component_tc.h component_tcc.h component_dsu.h component_ac.h component_eic.h component_adc.h component_port.h component_mtb.h component_sercom.h component_wdt.h component_i2s.h component_dmac.h component_evsys.h component_pac.h component_gclk.h component_usb.h component_pm.h component_dac.h component_sysctrl.h component_rtc.h component_nvmctrl.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../utils/cmsis/samd21/include/instance/: instance_pac1.h instance_sercom3.h instance_i2s.h instance_wdt.h instance_mtb.h instance_dac.h instance_tc6.h instance_tc4.h instance_evsys.h instance_sercom4.h instance_pac0.h instance_tcc1.h instance_usb.h instance_pm.h instance_sysctrl.h instance_port.h instance_tcc2.h instance_tc3.h instance_tc5.h instance_rtc.h instance_sercom5.h instance_tcc0.h instance_tc7.h instance_pac2.h instance_gclk.h instance_sercom1.h instance_dmac.h instance_sercom0.h instance_dsu.h instance_adc.h instance_eic.h instance_nvmctrl.h instance_ac.h instance_sercom2.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../utils/cmsis/samd21/include/pio/: pio_samd21e17a.h pio_samd21e16a.h pio_samd21e15a.h pio_samd21g17a.h pio_samd21j16a.h pio_samd21j18a.h pio_samd21g16a.h pio_samd21g18a.h pio_samd21j17a.h
  group sam0/utils/preprocessor
    ../../../../../utils/preprocessor/: stringz.h mrecursion.h preprocessor.h tpaste.h mrepeat.h
  group sam0/utils/header_files
    ../../../../../utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
