# IAR project at25dfx_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; BOARD=SAMD21_XPLAINED_PRO; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD21J18A__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../sam0/drivers/system/clock/clock_samd21; ../../../../../../../../sam0/drivers/port; ../../../hal/spi_polled; ../../../../../../../../sam0/utils/preprocessor; ../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../sam0/utils/cmsis/samd21/include/component; ../../../../../../../../sam0/utils; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/boards; ../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../common/services/serial; ../../../../../../../../common/utils; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../sam0/drivers/system/interrupt; ..; ../../../../../../../../sam0/utils/cmsis/samd21/include/pio; ../../..; ../../../../../../../../sam0/utils/cmsis/samd21/include/instance; ../../../../../../../../common/boards; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../sam0/drivers/system; ../..; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_unit_test_flash.bin
  ILINK.IlinkOutputFile: at25dfx_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21
    ../../../../../../../../sam0/drivers/system/clock/clock_samd21/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21g16a.h samd21j17a.h samd21j16a.h samd21e17a.h samd21e18a.h samd21.h samd21g17a.h samd21g18a.h samd21e16a.h samd21e15a.h samd21j18a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../sam0/utils/cmsis/samd21/include/component/: component_ac.h component_pm.h component_pac.h component_tcc.h component_rtc.h component_sercom.h component_dac.h component_dsu.h component_adc.h component_evsys.h component_tc.h component_sysctrl.h component_mtb.h component_gclk.h component_eic.h component_port.h component_nvmctrl.h component_i2s.h component_wdt.h component_usb.h component_dmac.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: instance_sercom1.h instance_tcc2.h instance_eic.h instance_mtb.h instance_sercom5.h instance_dac.h instance_pac1.h instance_tc5.h instance_tc7.h instance_sercom3.h instance_sercom0.h instance_tcc1.h instance_sercom4.h instance_adc.h instance_dsu.h instance_pm.h instance_ac.h instance_tc4.h instance_gclk.h instance_wdt.h instance_sercom2.h instance_tc6.h instance_evsys.h instance_tcc0.h instance_port.h instance_i2s.h instance_dmac.h instance_usb.h instance_tc3.h instance_nvmctrl.h instance_sysctrl.h instance_pac0.h instance_pac2.h instance_rtc.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: pio_samd21g18a.h pio_samd21e17a.h pio_samd21g16a.h pio_samd21g17a.h pio_samd21e16a.h pio_samd21j17a.h pio_samd21e15a.h pio_samd21j16a.h pio_samd21j18a.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group common2/components/memory/serial_flash/at25dfx
    ../../../: at25dfx.c at25dfx.h
  group common2/components/memory/serial_flash/at25dfx/unit_tests
    ../../: unit_tests.c
  group common2/components/memory/serial_flash/at25dfx/unit_tests/samd21_xplained_pro_polled_spi
    ../: conf_at25dfx.h conf_board.h conf_test.h conf_spi.h conf_clocks.h
  group common2/components/memory/serial_flash/at25dfx/unit_tests/samd21_xplained_pro_polled_spi/iar
    ./: asf.h
  group common2/components/memory/serial_flash/at25dfx/quick_start_basic
    ../../../quick_start_basic/: qs_at25dfx_basic.h
  group common2/components/memory/serial_flash/at25dfx/hal/spi_polled
    ../../../hal/spi_polled/: at25dfx_priv_hal.h at25dfx_hal.h
