# IAR project xmega_adc_oversampling_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../drivers/pmic; ../../../../utils; ../../../../../common/services/gfx_mono; ../..; ../../../../../common/services/ioport; ../../../../drivers/usart; ../../../../drivers/nvm; ../../../../../common/services/sleepmgr; ../../../../../common/utils; ../../../../drivers/adc; ../../../../../common/components/display/st7565r; ../../../../../common/services/clock; ../../../../boards/xmega_a3bu_xplained; ../../../../boards; ../../../../../common/services/gpio; ../../../../../common/services/delay; ../../../../../common/services/spi; ../../../../../common/boards; ../../../../utils/preprocessor; ..; ../../../../drivers/sleep; ../../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; GFX_MONO_C12832_A1Z=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/services/sleepmgr/xmega
    ../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/gfx_mono
    ../../../../../common/services/gfx_mono/: sysfont.c gfx_mono_generic.c gfx_mono_text.c gfx_mono_c12832_a1z.c gfx_mono_framebuffer.c
  group common/services/clock/xmega
    ../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../../common/services/spi/xmega_usart_spi/: usart_spi.c
  group common/services/ioport/xmega
    ../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/components/display/st7565r
    ../../../../../common/components/display/st7565r/: st7565r.c
  group xmega/boards/xmega_a3bu_xplained
    ../../../../boards/xmega_a3bu_xplained/: init.c
  group xmega/drivers/usart
    ../../../../drivers/usart/: usart.c
  group xmega/drivers/adc
    ../../../../drivers/adc/: adc.c
  group xmega/drivers/adc/xmega_aau
    ../../../../drivers/adc/xmega_aau/: adc_aau.c
  group xmega/drivers/nvm
    ../../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../drivers/cpu/: ccp.s
  group xmega/applications/xmega_adc_oversampling_demo
    ../../: adc_oversampling.c oversampling.c
