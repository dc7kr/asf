<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-b1_avrsbin1_compass-cal.ewp</path>
	</project>
</workspace>
