<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-b1_avrsbin1-demo.ewp</path>
	</project>
</workspace>
