<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-b1_avrsblp1_gesture.ewp</path>
	</project>
</workspace>
