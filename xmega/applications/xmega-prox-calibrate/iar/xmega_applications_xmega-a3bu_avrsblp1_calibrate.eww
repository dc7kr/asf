<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-a3bu_avrsblp1_calibrate.ewp</path>
	</project>
</workspace>
