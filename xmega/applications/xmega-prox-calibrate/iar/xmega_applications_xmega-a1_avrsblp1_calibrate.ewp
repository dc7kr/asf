# IAR project xmega_applications_xmega-a1_avrsblp1_calibrate.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: EXT_BOARD=SENSORS_XPLAINED_LIGHTPROX_1; BOARD=XMEGA_A1_XPLAINED; CONF_STDIO_REDIRECT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../drivers/pmic; ../../../drivers/ioport; ../../../../common/services/sensors; ../../../utils; ../../../../common/services; ../../../../common/services/gpio; ../../../../common/services/serial; ../../../drivers/usart; ../../../drivers/nvm; ../../../../common/services/sleepmgr; ../../../../common/utils; ../../../../common/services/clock; ../../../../common/utils/stdio/stdio_serial; ../../../boards/xmega_a1_xplained; ../../../boards; ../../../../common/services/twi; ../../../../common/services/delay; ../../../drivers/twi; ../../../../common/boards; ../../../utils/preprocessor; ../conf; ../../../drivers/sleep; ../../../../common/services/sensors/module_config; ../../../drivers/cpu; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; EXT_BOARD=SENSORS_XPLAINED_LIGHTPROX_1; BOARD=XMEGA_A1_XPLAINED; CONF_STDIO_REDIRECT
  XLINK.XclFile: lnk0t.xcl
  group thirdparty/sensors/libs/iar
    ../../../../thirdparty/sensors/libs/iar/: libsensors-atxmega128a1-debug.r90
  group xmega/drivers/nvm
    ../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/twi
    ../../../drivers/twi/: twim.c twis.c
  group xmega/drivers/usart
    ../../../drivers/usart/: usart.c
  group xmega/drivers/ioport
    ../../../drivers/ioport/: ioport.c
  group xmega/drivers/cpu
    ../../../drivers/cpu/: ccp.s
  group xmega/boards/xmega_a1_xplained
    ../../../boards/xmega_a1_xplained/: init.c
  group common/services/sensors
    ../../../../common/services/sensors/: sensor_nvram.c sensor.c sensor_platform.c sensor_bus.c
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c
  group common/services/sleepmgr/xmega
    ../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../common/services/clock/xmega/: sysclk.c
  group common/services/serial
    ../../../../common/services/serial/: usart_serial.c
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
  group common/applications/sensors/prox_calibrate
    ../../../../common/applications/sensors/prox_calibrate/: main.c
