<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega_a3bu_avrsbin1_display.ewp</path>
	</project>
</workspace>
