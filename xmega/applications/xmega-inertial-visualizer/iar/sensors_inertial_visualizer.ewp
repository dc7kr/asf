# IAR project sensors_inertial_visualizer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; IOPORT_XMEGA_COMPAT; BOARD=XMEGA_A3BU_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; CONF_STDIO_REDIRECT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../common/services/usb/class/cdc/device; ../../../../common/services/sensors; ../../../utils; ../../../../common/services; ../../../../common/services/twi; ../../../../common/services/ioport; ../../../../common/utils/stdio/stdio_usb; ../../../drivers/nvm; ../../../../common/services/sleepmgr; ../../../../common/utils; ../../../../common/services/usb/class/cdc; ../../../../common/services/clock; ../../../../common/services/usb/udc; ../../../../common/services/usb; ../../../boards; ../conf; ../../../../common/services/gpio; ../../../../common/services/delay; ../../../drivers/twi; ../../../boards/xmega_a3bu_xplained; ../../../drivers/usb; ../../../../common/boards; ../../../utils/preprocessor; ../../../drivers/sleep; ../../../../common/services/sensors/module_config; ../../../drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; IOPORT_XMEGA_COMPAT; BOARD=XMEGA_A3BU_XPLAINED; EXT_BOARD=SENSORS_XPLAINED_INERTIAL_1; CONF_STDIO_REDIRECT
  group thirdparty/sensors/libs/iar
    ../../../../thirdparty/sensors/libs/iar/: libsensors-atxmega256a3bu-debug.r90
  group xmega/drivers/nvm
    ../../../drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/twi
    ../../../drivers/twi/: twis.c twim.c
  group xmega/drivers/usb
    ../../../drivers/usb/: usb_device.c
  group xmega/drivers/cpu
    ../../../drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../boards/xmega_a3bu_xplained/: init.c
  group common/applications/sensors/inertial_visualizer
    ../../../../common/applications/sensors/inertial_visualizer/: main.c data_visualizer.c
  group common/services/sleepmgr/xmega
    ../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/usb/class/cdc/device
    ../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../common/services/usb/udc/: udc.c
  group common/services/clock/xmega
    ../../../../common/services/clock/xmega/: sysclk.c
  group common/services/sensors
    ../../../../common/services/sensors/: sensor.c sensor_nvram.c sensor_platform.c sensor_bus.c
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c
  group common/services/ioport/xmega
    ../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c
