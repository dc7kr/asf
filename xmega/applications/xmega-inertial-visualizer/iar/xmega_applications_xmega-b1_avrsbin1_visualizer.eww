<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-b1_avrsbin1_visualizer.ewp</path>
	</project>
</workspace>
