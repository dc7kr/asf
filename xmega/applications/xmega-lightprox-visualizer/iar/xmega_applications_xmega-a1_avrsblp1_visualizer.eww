<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-a1_avrsblp1_visualizer.ewp</path>
	</project>
</workspace>
