<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-a3bu_avrsbpr1_demo.ewp</path>
	</project>
</workspace>
