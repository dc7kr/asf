<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_applications_xmega-a1_avrsbpr1_demo.ewp</path>
	</project>
</workspace>
