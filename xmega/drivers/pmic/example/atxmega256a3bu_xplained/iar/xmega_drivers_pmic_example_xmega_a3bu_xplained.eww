<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_pmic_example_xmega_a3bu_xplained.ewp</path>
	</project>
</workspace>
