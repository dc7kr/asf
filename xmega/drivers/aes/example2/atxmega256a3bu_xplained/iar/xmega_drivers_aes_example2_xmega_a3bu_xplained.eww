<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_aes_example2_xmega_a3bu_xplained.ewp</path>
	</project>
</workspace>
