<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_tc_example2_xmega_a1_xplained.ewp</path>
	</project>
</workspace>
