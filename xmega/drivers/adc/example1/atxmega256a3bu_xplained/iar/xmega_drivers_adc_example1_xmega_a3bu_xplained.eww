<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_adc_example1_xmega_a3bu_xplained.ewp</path>
	</project>
</workspace>
