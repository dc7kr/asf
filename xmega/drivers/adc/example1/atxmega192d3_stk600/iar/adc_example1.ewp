# IAR project adc_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm192d3 ATxmega192D3
  ICCAVR.CCDefines: BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../boards/stk600/rc064x; ../../../../pmic; ../../../../../../common/services/clock; ../../../../cpu; ../../../../nvm; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../utils; ../../../../../utils/preprocessor; ../../../../sleep; ../../../../../boards; ..; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/gpio; ../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; IOPORT_XMEGA_COMPAT
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group xmega/boards/stk600/rc064x
    ../../../../../boards/stk600/rc064x/: init.c
  group xmega/drivers/adc
    ../../../: adc.c
  group xmega/drivers/adc/example1
    ../../: adc_example1.c
  group xmega/drivers/adc/xmega_bcd
    ../../../xmega_bcd/: adc_bcd.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
