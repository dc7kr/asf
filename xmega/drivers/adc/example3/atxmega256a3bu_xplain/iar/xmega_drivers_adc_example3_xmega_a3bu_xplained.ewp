# IAR project xmega_drivers_adc_example3_xmega_a3bu_xplained.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../cpu; ../../../../pmic; ../../../../../boards/xmega_a3bu_xplained; ../../../../../../common/services/clock; ..; ../../../../../../common/boards; ../../../../../utils; ../../../../ioport; ../../../../../utils/preprocessor; ../../../../../../common/services/gpio; ../../../../../../common/utils; ../../../../../boards; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../sleep; ../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../boards/xmega_a3bu_xplained/: init.c
  group xmega/drivers/adc
    ../../../: adc.c
  group xmega/drivers/adc/example3
    ../../: adc_example3.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/ioport
    ../../../../ioport/: ioport.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
