<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_nvm_example1_xmega_a1_xplained.ewp</path>
	</project>
</workspace>
