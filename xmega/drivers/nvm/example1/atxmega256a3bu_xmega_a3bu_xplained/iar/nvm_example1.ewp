# IAR project nvm_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/clock; ../../../../cpu; ../../../../../../common/boards; ../../../../../../common/services/ioport; ..; ../../../../../utils; ../../../../../boards/xmega_a3bu_xplained; ../../../../../utils/preprocessor; ../../../../../boards; ../../..; ../../../../../../common/utils; ../../../../../../common/services/gpio; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group xmega/drivers/nvm
    ../../../: nvm.c nvm_asm.s
  group xmega/drivers/nvm/example1
    ../../: example1_xmega.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../boards/xmega_a3bu_xplained/: init.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
