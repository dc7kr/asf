<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_nvm_example3_xmega_a3bu_xplained.ewp</path>
	</project>
</workspace>
