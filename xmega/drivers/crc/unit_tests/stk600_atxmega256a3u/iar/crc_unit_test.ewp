# IAR project crc_unit_test.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../pmic; ../../../../../../common/boards; ../../../../../utils; ../../../../dma; ../../../../../boards/stk600/rc064x; ../../../../../../common/services/serial; ..; ../..; ../../../../../../common/services/serial/xmega_usart; ../../../../usart; ../../../../nvm; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../common/services/clock; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../boards; ../../../../../../common/services/gpio; ../../../../../../common/services/ioport; ../../../../../../common/services/hugemem; ../../..; ../../../../../utils/preprocessor; ../../../../sleep; ../../../../cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/services/ioport/xmega
    ../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/hugemem/avr8
    ../../../../../../common/services/hugemem/avr8/: avr8_hugemem.c
  group common/services/clock/xmega
    ../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group xmega/boards/stk600/rc064x
    ../../../../../boards/stk600/rc064x/: init.c
  group xmega/drivers/crc
    ../../../: crc.c
  group xmega/drivers/crc/unit_tests
    ../../: unit_tests.c
  group xmega/drivers/nvm
    ../../../../nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../usart/: usart.c
  group xmega/drivers/dma
    ../../../../dma/: dma.c
  group xmega/drivers/cpu
    ../../../../cpu/: ccp.s
