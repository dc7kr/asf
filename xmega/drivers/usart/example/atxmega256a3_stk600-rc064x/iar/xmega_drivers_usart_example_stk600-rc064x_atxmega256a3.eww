<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_usart_example_stk600-rc064x_atxmega256a3.ewp</path>
	</project>
</workspace>
