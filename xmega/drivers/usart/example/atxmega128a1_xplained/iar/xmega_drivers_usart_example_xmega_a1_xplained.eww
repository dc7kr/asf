<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_drivers_usart_example_xmega_a1_xplained.ewp</path>
	</project>
</workspace>
