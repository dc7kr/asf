<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_services_pwm_example2_xmega-a1_xplained.ewp</path>
	</project>
</workspace>
