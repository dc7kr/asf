<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_services_timeout_example2_xmega_a1_xplained.ewp</path>
	</project>
</workspace>
