<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\xmega_services_timeout_unit_tests_a1_xplained.ewp</path>
	</project>
</workspace>
