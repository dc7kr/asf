# IAR project apps_prime_base_serial_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CP16B_0 Atmel ATSAM4CP16B Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __FREERTOS__; ARM_MATH_CM4=true; __SAM4CP16B_0__; BOARD=SAM4CP16BMB
  ICCARM.CCIncludePath2: ../..; ../../../../../../sam/drivers/wdt; ../../../../phy/atpl230/include; ../../../../../../common/boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/sam4cp/source/templates; ../../../../sscs/sscs-4-32/include; ../../../../mac/mac_1_3/include; ../../../../../../sam/utils/header_files; ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../sam/drivers/efc; ../../../../pal/atpl230_primemac13/module_config; ../../../../oss; ../../../../mac/mac_1_3/module_config; ../../../../../../common/services/serial; ../../../../../../sam/drivers/gpbr; ../../../../../../sam/utils/cmsis/sam4cp/include; ../../../../../../common/services/clock; ../../../../../../sam/services/flash_efc; ../../../../../../sam/drivers/spi; ../../../../../../sam/drivers/supc; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../../../../../sam/boards/sam4cp16bmb; ../../../../../../sam/services/plc/pplc_if/atpl230; ../../../../../../sam/services/plc/busart_if; ../../../../mac/mac_1_3/addons/bootloader; ../../../../../../sam/drivers/slcdc; ../../../../../freertos/freertos-7.3.0/source/include; ../../../../mac/mac_1_3/addons/serial_if; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../sscs/sscs-4-32/addons/serial_if; ../../../../../../sam/drivers/pdc; ../../../../../../sam/services/plc/hal/prime; ../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/components/display/c42364a; ../../../../../../sam/drivers/tc; ../../../../../../sam/services/plc/pcrc; ../../../../../../common/services/serial/sam_uart; ../../../../../../sam/services/plc/buart_if; ../../../../phy/atpl230/coupling_config; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ../../../../../../sam/services/plc/usi; ../../../../pal/atpl230_primemac13/include; ../../../../../../sam/drivers/usart; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_base_serial_flash.bin
  ILINK.IlinkOutputFile: apps_prime_base_serial_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4cp/iar/sam4cp16b_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/prime/sscs/sscs-4-32/libs/iar
    ../../../../sscs/sscs-4-32/libs/iar/: libsam4c-sscs432-bn-iar.a
  group thirdparty/prime/sscs/sscs-4-32/addons/serial_if
    ../../../../sscs/sscs-4-32/addons/serial_if/: serial_432_if.c serial_432_if.h
  group thirdparty/prime/sscs/sscs-4-32/include
    ../../../../sscs/sscs-4-32/include/: dl432.h sscs432.h
  group thirdparty/prime/mac/mac_1_3/libs/iar
    ../../../../mac/mac_1_3/libs/iar/: libsam4c-mac13-bn-iar.a
  group thirdparty/prime/mac/mac_1_3/addons/serial_if
    ../../../../mac/mac_1_3/addons/serial_if/: serial_if_plme.c serial_if_sniffer.c serial_if_mlme.c serial_if_sniffer.h serial_if_plme.h serial_if_mlme.h
  group thirdparty/prime/mac/mac_1_3/addons/bootloader
    ../../../../mac/mac_1_3/addons/bootloader/: boot_regions_sam4cp16b_0.h
  group thirdparty/prime/mac/mac_1_3/source
    ../../../../mac/mac_1_3/source/: PrimeVersion.c
  group thirdparty/prime/mac/mac_1_3/module_config
    ../../../../mac/mac_1_3/module_config/: conf_mac.c conf_mac.h
  group thirdparty/prime/mac/mac_1_3/include
    ../../../../mac/mac_1_3/include/: bmngt.h mngl.h prime.h
  group thirdparty/prime/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/prime/phy/atpl230/source
    ../../../../phy/atpl230/source/: atpl230_iir_filter.c atpl230.c
  group thirdparty/prime/phy/atpl230/coupling_config
    ../../../../phy/atpl230/coupling_config/: conf_atpl230.c conf_atpl230.h
  group thirdparty/prime/phy/atpl230/include
    ../../../../phy/atpl230/include/: atpl230_reg.h atpl230.h atpl230_iir_filter.h atpl230_version.h
  group thirdparty/prime/pal/atpl230_primemac13/source
    ../../../../pal/atpl230_primemac13/source/: pal.c
  group thirdparty/prime/pal/atpl230_primemac13/module_config
    ../../../../pal/atpl230_primemac13/module_config/: conf_pal.h
  group thirdparty/prime/pal/atpl230_primemac13/include
    ../../../../pal/atpl230_primemac13/include/: pal.h
  group thirdparty/prime/apps/prime_base_serial
    ../../: main.c
  group thirdparty/prime/apps/prime_base_serial/sam4cp16b_sam4cp16bmb
    ../: conf_c42364a_slcdc.h conf_buart_if.h conf_usi.h conf_uart_serial.h conf_busart_if.h conf_prime.h conf_oss.h conf_clock.h conf_board.h conf_pplc_if.h conf_sleepmgr.h conf_example.h FreeRTOSConfig.h conf_slcdc.h conf_phy.h
  group thirdparty/prime/apps/prime_base_serial/sam4cp16b_sam4cp16bmb/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: FreeRTOS_CLI.c tasks.c list.c timers.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: StackMacros.h task.h mpu_wrappers.h FreeRTOS.h portable.h list.h semphr.h FreeRTOS_CLI.h projdefs.h timers.h queue.h croutine.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4cp
    ../../../../../../common/services/clock/sam4cp/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/services/plc/hal/prime
    ../../../../../../sam/services/plc/hal/prime/: hal.c hal.h
  group sam/services/plc/pplc_if/atpl230
    ../../../../../../sam/services/plc/pplc_if/atpl230/: pplc_if.c pplc_if.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc
    ../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cp/source/templates
    ../../../../../../sam/utils/cmsis/sam4cp/source/templates/: system_sam4cp.c
  group sam/utils/cmsis/sam4cp/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cp/source/templates/iar/: startup_sam4cp.c
  group sam/utils/cmsis/sam4cp/include
    ../../../../../../sam/utils/cmsis/sam4cp/include/: sam4cp_0.h system_sam4cp.h sam4cp.h sam4cp16b_0.h sam4cp16b_1.h sam4cp_1.h
  group sam/utils/cmsis/sam4cp/include/instance
    ../../../../../../sam/utils/cmsis/sam4cp/include/instance/: instance_usart4.h instance_usart2.h instance_ipc1.h instance_spi0.h instance_usart0.h instance_rswdt.h instance_matrix0.h instance_smc1.h instance_icm.h instance_tc0.h instance_uart0.h instance_supc.h instance_uart1.h instance_wdt.h instance_rtc.h instance_trng.h instance_twi1.h instance_cmcc0.h instance_tc1.h instance_gpbr.h instance_rtt.h instance_twi0.h instance_slcdc.h instance_efc.h instance_rstc.h instance_pioa.h instance_smc0.h instance_piob.h instance_pwm.h instance_spi1.h instance_usart3.h instance_ipc0.h instance_usart1.h instance_matrix1.h instance_aes.h instance_chipid.h instance_pioc.h instance_adc.h instance_cmcc1.h instance_pmc.h
  group sam/utils/cmsis/sam4cp/include/component
    ../../../../../../sam/utils/cmsis/sam4cp/include/component/: component_supc.h component_rtc.h component_adc.h component_chipid.h component_usart.h component_smc.h component_gpbr.h component_cmcc.h component_ipc.h component_aes.h component_icm.h component_pio.h component_twi.h component_matrix.h component_pdc.h component_trng.h component_efc.h component_slcdc.h component_pmc.h component_uart.h component_wdt.h component_rstc.h component_rtt.h component_tc.h component_spi.h component_rswdt.h component_pwm.h
  group sam/utils/cmsis/sam4cp/include/pio
    ../../../../../../sam/utils/cmsis/sam4cp/include/pio/: pio_sam4cp16b.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4cp16bmb
    ../../../../../../sam/boards/sam4cp16bmb/: init.c sam4cp16bmb.h led.h
  group sam/components/display/c42364a
    ../../../../../../sam/components/display/c42364a/: c42364a_slcdc.c c42364a.h c42364a_font.h c42364a_segmap.h
