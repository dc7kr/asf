# IAR project apps_prime_base_serial_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __FREERTOS__; __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  ICCARM.CCIncludePath2: ../..; ..; ../../../../phy/atpl230/include; ../../../../../../common/boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../sscs/sscs-4-32/include; ../../../../mac/mac_1_3/include; ../../../../../../sam/utils/header_files; ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam; ../../../../../../sam/drivers/efc; ../../../../pal/atpl230_primemac13/module_config; ../../../../oss; ../../../../mac/mac_1_3/module_config; ../../../../../../common/services/serial; ../../../../../../sam/drivers/gpbr; ../../../../../../common/services/clock; ../../../../../../sam/utils/cmsis/sam4cm/source/templates; ../../../../../../sam/services/flash_efc; ../../../../../../sam/drivers/spi; ../../../../../../sam/boards; ../../../../../../sam/drivers/pdc; ../../../../../../common/utils; ../../../../../../sam/services/plc/pplc_if/atpl230; ../../../../../../sam/services/plc/busart_if; ../../../../mac/mac_1_3/addons/bootloader; ../../../../../freertos/freertos-7.3.0/source/include; ../../../../mac/mac_1_3/addons/serial_if; ../../../../../../common/utils/stdio/stdio_serial; ../../../../sscs/sscs-4-32/addons/serial_if; ../../../../../../sam/drivers/wdt; ../../../../../../sam/boards/sam4cms_db; ../../../../../../sam/services/plc/hal/prime; ../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/drivers/tc; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../sam/services/plc/buart_if; ../../../../phy/atpl230/coupling_config; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ../../../../../../sam/services/plc/usi; ../../../../pal/atpl230_primemac13/include; ../../../../../../sam/utils/cmsis/sam4cm/include; ../../../../../../sam/services/plc/pcrc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_prime_base_serial_flash.bin
  ILINK.IlinkOutputFile: apps_prime_base_serial_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4cm/iar/sam4cms16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/prime/sscs/sscs-4-32/libs/iar
    ../../../../sscs/sscs-4-32/libs/iar/: libsam4c-sscs432-bn-iar.a
  group thirdparty/prime/sscs/sscs-4-32/addons/serial_if
    ../../../../sscs/sscs-4-32/addons/serial_if/: serial_432_if.c serial_432_if.h
  group thirdparty/prime/sscs/sscs-4-32/include
    ../../../../sscs/sscs-4-32/include/: dl432.h sscs432.h
  group thirdparty/prime/mac/mac_1_3/libs/iar
    ../../../../mac/mac_1_3/libs/iar/: libsam4c-mac13-bn-iar.a
  group thirdparty/prime/mac/mac_1_3/addons/serial_if
    ../../../../mac/mac_1_3/addons/serial_if/: serial_if_plme.c serial_if_sniffer.c serial_if_mlme.c serial_if_sniffer.h serial_if_plme.h serial_if_mlme.h
  group thirdparty/prime/mac/mac_1_3/addons/bootloader
    ../../../../mac/mac_1_3/addons/bootloader/: boot_regions_sam4cms16c_0.h
  group thirdparty/prime/mac/mac_1_3/source
    ../../../../mac/mac_1_3/source/: PrimeVersion.c
  group thirdparty/prime/mac/mac_1_3/module_config
    ../../../../mac/mac_1_3/module_config/: conf_mac.c conf_mac.h
  group thirdparty/prime/mac/mac_1_3/include
    ../../../../mac/mac_1_3/include/: bmngt.h mngl.h prime.h
  group thirdparty/prime/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/prime/phy/atpl230/source
    ../../../../phy/atpl230/source/: atpl230_iir_filter.c atpl230.c
  group thirdparty/prime/phy/atpl230/coupling_config
    ../../../../phy/atpl230/coupling_config/: conf_atpl230.c conf_atpl230.h
  group thirdparty/prime/phy/atpl230/include
    ../../../../phy/atpl230/include/: atpl230.h atpl230_reg.h atpl230_iir_filter.h atpl230_version.h
  group thirdparty/prime/pal/atpl230_primemac13/source
    ../../../../pal/atpl230_primemac13/source/: pal.c
  group thirdparty/prime/pal/atpl230_primemac13/module_config
    ../../../../pal/atpl230_primemac13/module_config/: conf_pal.h
  group thirdparty/prime/pal/atpl230_primemac13/include
    ../../../../pal/atpl230_primemac13/include/: pal.h
  group thirdparty/prime/apps/prime_base_serial
    ../../: main.c
  group thirdparty/prime/apps/prime_base_serial/sam4cms16c_sam4cms_db
    ../: conf_board.h conf_buart_if.h conf_usi.h conf_uart_serial.h conf_busart_if.h conf_prime.h conf_oss.h conf_pplc_if.h conf_example.h FreeRTOSConfig.h conf_clock.h conf_phy.h
  group thirdparty/prime/apps/prime_base_serial/sam4cms16c_sam4cms_db/iar
    ./: asf.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: FreeRTOS_CLI.c tasks.c list.c timers.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: queue.h semphr.h StackMacros.h FreeRTOS.h mpu_wrappers.h portable.h list.h timers.h FreeRTOS_CLI.h projdefs.h croutine.h task.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4cm
    ../../../../../../common/services/clock/sam4cm/: sysclk.c sysclk.h pll.h osc.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/services/plc/hal/prime
    ../../../../../../sam/services/plc/hal/prime/: hal.c hal.h
  group sam/services/plc/pplc_if/atpl230
    ../../../../../../sam/services/plc/pplc_if/atpl230/: pplc_if.c pplc_if.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/wdt
    ../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/boards/sam4cms_db
    ../../../../../../sam/boards/sam4cms_db/: init.c sam4cms_db.h led.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_1.h sam4cmp16c_1.h sam4cmp8c_1.h sam4cmp16c_0.h sam4cms16c_0.h sam4cm.h sam4cms8c_0.h sam4cms16c_1.h sam4cmp8c_0.h system_sam4cm.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../sam/utils/cmsis/sam4cm/include/instance/: slcdc.h trng.h uart1.h adc.h tc0.h tc1.h chipid.h ipc0.h wdt.h rswdt.h uart0.h pwm.h icm.h pmc.h rstc.h spi1.h usart2.h smc0.h efc.h rtc.h supc.h matrix0.h spi0.h usart0.h twi1.h piob.h cmcc1.h aes.h usart3.h pioc.h smc1.h pioa.h matrix1.h rtt.h twi0.h gpbr.h usart1.h ipc1.h cmcc0.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../sam/utils/cmsis/sam4cm/include/component/: chipid.h rtt.h tc.h pmc.h pio.h spi.h uart.h trng.h supc.h smc.h twi.h icm.h cmcc.h aes.h wdt.h gpbr.h rswdt.h usart.h efc.h ipc.h pdc.h rstc.h matrix.h adc.h rtc.h pwm.h slcdc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cmp8c.h sam4cms8c.h sam4cms16c.h sam4cmp16c.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
