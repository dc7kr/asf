# IAR project apps_phy_sniffer_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  ICCARM.CCIncludePath2: ../../../../include; ../../../../../../../../common/boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/utils/header_files; ../..; ../../../../../../../../common/services/serial; ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/supc; ../../../../../../../../sam/drivers/pdc; ../../../../../../../../common/utils; ..; ../../../../../../../../sam/services/plc/pplc_if/atpl230; ../../../../../../../../sam/services/plc/busart_if; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../sam/boards/sam4cms_db; ../../../../addons/sniffer_if; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/tc; ../../../../../../../../sam/drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../sam/services/plc/buart_if; ../../../../coupling_config; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/services/plc/usi; ../../../../../../../../sam/utils/cmsis/sam4cm/include; ../../../../../../../../sam/services/plc/pcrc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_sniffer_tool_flash.bin
  ILINK.IlinkOutputFile: apps_phy_sniffer_tool_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4cm/iar/sam4cms16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/prime/phy/atpl230/coupling_config
    ../../../../coupling_config/: conf_atpl230.c conf_atpl230.h
  group thirdparty/prime/phy/atpl230/addons/sniffer_if
    ../../../../addons/sniffer_if/: sniffer_if.c sniffer_if.h
  group thirdparty/prime/phy/atpl230/apps/phy_sniffer_tool
    ../../: phy_sniffer_tool.c
  group thirdparty/prime/phy/atpl230/apps/phy_sniffer_tool/sam4cms16c_sam4cms_db
    ../: conf_buart_if.h conf_usi.h conf_uart_serial.h conf_busart_if.h conf_clock.h conf_board.h conf_pplc_if.h conf_phy.h
  group thirdparty/prime/phy/atpl230/apps/phy_sniffer_tool/sam4cms16c_sam4cms_db/iar
    ./: asf.h
  group thirdparty/prime/phy/atpl230/source
    ../../../../source/: atpl230_iir_filter.c atpl230.c
  group thirdparty/prime/phy/atpl230/include
    ../../../../include/: atpl230_iir_filter.h atpl230.h atpl230_reg.h atpl230_version.h
  group sam/services/plc/buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pplc_if/atpl230
    ../../../../../../../../sam/services/plc/pplc_if/atpl230/: pplc_if.c pplc_if.h
  group sam/services/plc/usi
    ../../../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/boards/sam4cms_db
    ../../../../../../../../sam/boards/sam4cms_db/: init.c led.h sam4cms_db.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cms8c_0.h sam4cmp8c_0.h sam4cms16c_1.h sam4cmp16c_0.h sam4cmp8c_1.h sam4cm.h system_sam4cm.h sam4cms8c_1.h sam4cms16c_0.h sam4cmp16c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/instance/: cmcc0.h efc.h matrix0.h smc1.h wdt.h ipc1.h uart1.h spi0.h twi1.h rtc.h chipid.h usart3.h usart0.h usart2.h tc0.h tc1.h rswdt.h adc.h gpbr.h ipc0.h pioa.h pmc.h pioc.h matrix1.h uart0.h usart1.h rstc.h twi0.h supc.h smc0.h rtt.h trng.h slcdc.h cmcc1.h piob.h pwm.h icm.h spi1.h aes.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/component/: gpbr.h tc.h adc.h chipid.h twi.h matrix.h rswdt.h rstc.h efc.h slcdc.h pwm.h trng.h rtt.h usart.h supc.h pdc.h spi.h pio.h smc.h pmc.h uart.h aes.h icm.h rtc.h wdt.h ipc.h cmcc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cms8c.h sam4cmp16c.h sam4cmp8c.h sam4cms16c.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h mrepeat.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4cm
    ../../../../../../../../common/services/clock/sam4cm/: sysclk.c sysclk.h genclk.h pll.h osc.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
