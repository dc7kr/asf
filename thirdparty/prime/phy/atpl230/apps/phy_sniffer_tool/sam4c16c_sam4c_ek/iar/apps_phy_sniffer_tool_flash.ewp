# IAR project apps_phy_sniffer_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4C16C_0 Atmel ATSAM4C16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  ICCARM.CCIncludePath2: ../../../../include; ../../../../../../../../common/boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/drivers/usart; ..; ../../../../../../../../sam/utils/header_files; ../..; ../../../../../../../../common/services/serial; ../../../../../../../../sam/utils/cmsis/sam4c/source/templates; ../../../../../../../../sam/boards/sam4c_ek; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/supc; ../../../../../../../../sam/drivers/pdc; ../../../../../../../../common/utils; ../../../../../../../../sam/services/plc/pplc_if/atpl230; ../../../../../../../../sam/services/plc/busart_if; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../addons/sniffer_if; ../../../../../../../../sam/drivers/pdc/pdc_uart_example; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/tc; ../../../../../../../../sam/services/plc/pcrc; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../sam/services/plc/buart_if; ../../../../coupling_config; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/services/plc/usi; ../../../../../../../../sam/utils/cmsis/sam4c/include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4C_EK; ARM_MATH_CM4=true; __SAM4C16C_0__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_sniffer_tool_flash.bin
  ILINK.IlinkOutputFile: apps_phy_sniffer_tool_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4c/iar/sam4c16c_0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4c/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4c/source/templates/: system_sam4c.c
  group sam/utils/cmsis/sam4c/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4c/source/templates/iar/: startup_sam4c.c
  group sam/utils/cmsis/sam4c/include
    ../../../../../../../../sam/utils/cmsis/sam4c/include/: sam4c32c_0.h sam4c8c_1.h sam4c.h sam4c16c_0.h sam4c32e_1.h sam4c32e_0.h sam4c32c_1.h sam4c8c_0.h system_sam4c.h sam4c16c_1.h
  group sam/utils/cmsis/sam4c/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4c/include/instance/: instance_matrix1.h instance_ipc1.h instance_adc.h instance_aes.h instance_uotghs.h instance_pwm.h instance_uart0.h instance_tc1.h instance_icm.h instance_efc0.h instance_pmc.h instance_rstc.h instance_matrix0.h instance_piob.h instance_gpbr.h instance_supc.h instance_twi0.h instance_uart1.h instance_tc0.h instance_cmcc0.h instance_usart1.h instance_spi0.h instance_rswdt.h instance_pioa.h instance_usart3.h instance_pioc.h instance_efc1.h instance_twi1.h instance_smc1.h instance_rtt.h instance_spi1.h instance_chipid.h instance_ipc0.h instance_usart0.h instance_cmcc1.h instance_slcdc.h instance_efc.h instance_usart2.h instance_rtc.h instance_usart4.h instance_trng.h instance_wdt.h instance_smc0.h instance_piod.h
  group sam/utils/cmsis/sam4c/include/component
    ../../../../../../../../sam/utils/cmsis/sam4c/include/component/: component_gpbr.h component_trng.h component_chipid.h component_rswdt.h component_supc.h component_tc.h component_pwm.h component_uart.h component_icm.h component_ipc.h component_slcdc.h component_cmcc.h component_uotghs.h component_pio.h component_smc.h component_matrix.h component_spi.h component_efc.h component_rstc.h component_usart.h component_pdc.h component_rtc.h component_aes.h component_wdt.h component_adc.h component_twi.h component_rtt.h component_pmc.h
  group sam/utils/cmsis/sam4c/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4c/include/pio/: pio_sam4c32c.h pio_sam4c16c.h pio_sam4c8c.h pio_sam4c32e.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/services/plc/buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pplc_if/atpl230
    ../../../../../../../../sam/services/plc/pplc_if/atpl230/: pplc_if.c pplc_if.h
  group sam/services/plc/usi
    ../../../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/pdc/pdc_uart_example
    ../../../../../../../../sam/drivers/pdc/pdc_uart_example/: pdc_uart_example.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/tc/tc_capture_waveform_example
    ../../../../../../../../sam/drivers/tc/tc_capture_waveform_example/: tc_capture_waveform_example.h
  group sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek
    ../../../../../../../../sam/drivers/tc/tc_capture_waveform_example/sam4e16e_sam4e_ek/: conf_board.h
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/boards/sam4c_ek
    ../../../../../../../../sam/boards/sam4c_ek/: init.c led.h sam4c_ek.h
  group thirdparty/prime/phy/atpl230/coupling_config
    ../../../../coupling_config/: conf_atpl230.c conf_atpl230.h
  group thirdparty/prime/phy/atpl230/addons/sniffer_if
    ../../../../addons/sniffer_if/: sniffer_if.c sniffer_if.h
  group thirdparty/prime/phy/atpl230/apps/phy_sniffer_tool
    ../../: phy_sniffer_tool.c
  group thirdparty/prime/phy/atpl230/apps/phy_sniffer_tool/sam4c16c_sam4c_ek
    ../: conf_buart_if.h conf_usi.h conf_uart_serial.h conf_busart_if.h conf_clock.h conf_board.h conf_pplc_if.h conf_phy.h
  group thirdparty/prime/phy/atpl230/apps/phy_sniffer_tool/sam4c16c_sam4c_ek/iar
    ./: asf.h
  group thirdparty/prime/phy/atpl230/source
    ../../../../source/: atpl230_iir_filter.c atpl230.c
  group thirdparty/prime/phy/atpl230/include
    ../../../../include/: atpl230_iir_filter.h atpl230.h atpl230_reg.h atpl230_version.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4c
    ../../../../../../../../common/services/clock/sam4c/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
