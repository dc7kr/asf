<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\ijp_example.ewp</path>
	</project>
</workspace>
