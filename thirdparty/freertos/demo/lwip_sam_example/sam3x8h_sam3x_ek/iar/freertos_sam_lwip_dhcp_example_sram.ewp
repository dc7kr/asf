# IAR project freertos_sam_lwip_dhcp_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HTTP_USED=1; FREERTOS_USED; TFTP_USED=1; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/rstc; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/components/ethernet_phy/dm9161a; ../../../../../../sam/drivers/pmc; ../../../../../../sam/boards/sam3x_ek; ../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../lwip_avr32_uc3_example/network/basictftp; ../../../../../lwip/lwip-1.4.0/src/include; ../../../../../../common/services/serial; ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../common/utils; ../../../../../../sam/drivers/emac; ../..; ../../../../freertos-7.0.0/source/portable/iar/sam; ../../../common/include; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../lwip/lwip-1.4.0/src/include/lwip; ../../network; ../../../../../../common/services/gpio; ../../../../../../sam/drivers/uart; ../../../../freertos-7.0.0/source/include; ../../../../../../sam/utils; ../../../lwip_avr32_uc3_example/network/basicweb; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../lwip/lwip-port-1.4.0/sam/include; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; ..; ../../../../../../sam/drivers/tc; ../../../../../lwip/lwip-1.4.0/src/include/ipv4; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_lwip_dhcp_example_sram.bin
  ILINK.IlinkOutputFile: freertos_sam_lwip_dhcp_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x8000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../../../lwip/lwip-1.4.0/src/core/: tcp_in.c stats.c pbuf.c lwip_timers_140.c dhcp.c def.c sys.c tcp_out.c mem.c memp.c dns.c init.c tcp.c raw.c udp.c netif.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../../../lwip/lwip-1.4.0/src/core/ipv4/: inet_chksum.c autoip.c ip_addr.c ip_frag.c igmp.c ip.c inet.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../../../lwip/lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../../../lwip/lwip-1.4.0/src/api/: netbuf.c netdb.c sockets.c api_msg.c err.c tcpip.c api_lib.c netifapi.c
  group thirdparty/lwip/lwip-port-1.4.0/sam
    ../../../../../lwip/lwip-port-1.4.0/sam/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/netif
    ../../../../../lwip/lwip-port-1.4.0/sam/netif/: ethernetif.c
  group thirdparty/freertos/demo/lwip_sam_example
    ../../: main.c
  group thirdparty/freertos/demo/lwip_sam_example/partest
    ../../partest/: ParTest.c
  group thirdparty/freertos/demo/lwip_sam_example/network
    ../../network/: ethernet.c
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: flash.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basictftp
    ../../../lwip_avr32_uc3_example/network/basictftp/: BasicTFTP.c
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicweb
    ../../../lwip_avr32_uc3_example/network/basicweb/: BasicWEB.c
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3x
    ../../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group sam/components/ethernet_phy/dm9161a
    ../../../../../../sam/components/ethernet_phy/dm9161a/: ethernet_phy.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/emac
    ../../../../../../sam/drivers/emac/: emac.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam/boards/sam3x_ek
    ../../../../../../sam/boards/sam3x_ek/: led.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
