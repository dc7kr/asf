# IAR project freertos_sam_lwip_dhcp_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: HTTP_USED=1; FREERTOS_USED; __SAM4E16E__; TFTP_USED=1; BOARD=SAM4E_EK; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../freertos-7.0.0/source/portable/iar/sam_cm4f; ../../../../../../sam/utils/header_files; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/components/ethernet_phy/ksz8051mnl; ../../../../../../sam/drivers/pmc; ../../../lwip_avr32_uc3_example/network/basictftp; ../../../../../../sam/utils/fpu; ../../../../../lwip/lwip-1.4.0/src/include; ../../../../../../common/services/serial; ../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../common/utils; ../../../../../../sam/drivers/gmac; ../..; ../../../common/include; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../lwip/lwip-1.4.0/src/include/lwip; ../../network; ../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../lwip/lwip-1.4.0/src/include/ipv4; ..; ../../../../../../sam/drivers/uart; ../../../../freertos-7.0.0/source/include; ../../../../../../sam/utils; ../../../lwip_avr32_uc3_example/network/basicweb; ../../../../../../sam/drivers/usart; ../../../../../../common/services/serial/sam_uart; ../../../../../../common/boards; ../../../../../lwip/lwip-port-1.4.0/sam/include; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/tc; ../../../../../../sam/boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_lwip_dhcp_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_lwip_dhcp_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x8000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../../../lwip/lwip-1.4.0/src/core/: dhcp.c tcp_in.c stats.c pbuf.c lwip_timers_140.c def.c sys.c tcp_out.c mem.c memp.c dns.c init.c tcp.c raw.c udp.c netif.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../../../lwip/lwip-1.4.0/src/core/ipv4/: inet_chksum.c autoip.c ip_addr.c ip_frag.c igmp.c ip.c inet.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../../../lwip/lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../../../lwip/lwip-1.4.0/src/api/: netbuf.c netdb.c sockets.c err.c api_msg.c tcpip.c api_lib.c netifapi.c
  group thirdparty/lwip/lwip-1.4.0/src/include/lwip
    ../../../../../lwip/lwip-1.4.0/src/include/lwip/: api.h init.h pbuf.h timers.h raw.h memp_std.h sockets.h tcp_impl.h snmp_asn1.h def.h udp.h snmp_structs.h debug.h memp.h err.h sys.h dns.h opt.h sio.h mem.h snmp_msg.h arch.h tcpip.h netifapi.h netdb.h netif.h snmp.h api_msg.h netbuf.h dhcp.h tcp.h stats.h
  group thirdparty/lwip/lwip-1.4.0/src/include/netif
    ../../../../../lwip/lwip-1.4.0/src/include/netif/: etharp.h ppp_oe.h
  group thirdparty/lwip/lwip-1.4.0/src/include/ipv4/lwip
    ../../../../../lwip/lwip-1.4.0/src/include/ipv4/lwip/: igmp.h icmp.h autoip.h ip_frag.h inet_chksum.h ip.h ip_addr.h inet.h
  group thirdparty/lwip/lwip-port-1.4.0/sam
    ../../../../../lwip/lwip-port-1.4.0/sam/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/netif
    ../../../../../lwip/lwip-port-1.4.0/sam/netif/: ethernetif_sam4.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/netif
    ../../../../../lwip/lwip-port-1.4.0/sam/include/netif/: ethernetif.h
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/arch
    ../../../../../lwip/lwip-port-1.4.0/sam/include/arch/: cc.h perf.h sys_arch.h
  group thirdparty/freertos/demo/lwip_sam_example
    ../../: main.c FreeRTOSConfig.h lwipopts.h
  group thirdparty/freertos/demo/lwip_sam_example/partest
    ../../partest/: ParTest.c
  group thirdparty/freertos/demo/lwip_sam_example/network
    ../../network/: ethernet.c ethernet.h
  group thirdparty/freertos/demo/lwip_sam_example/sam4e16e_sam4e_ek
    ../: conf_uart_serial.h conf_lwip_threads.h conf_clock.h conf_board.h conf_eth.h
  group thirdparty/freertos/demo/lwip_sam_example/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group thirdparty/freertos/demo/common/minimal
    ../../../common/minimal/: flash.c
  group thirdparty/freertos/demo/common/include
    ../../../common/include/: partest.h flash.h
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basictftp
    ../../../lwip_avr32_uc3_example/network/basictftp/: BasicTFTP.c BasicTFTP.h
  group thirdparty/freertos/demo/lwip_avr32_uc3_example/network/basicweb
    ../../../lwip_avr32_uc3_example/network/basicweb/: BasicWEB.c BasicWEB.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c croutine.c tasks.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam_cm4f
    ../../../../freertos-7.0.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: semphr.h list.h FreeRTOS.h projdefs.h mpu_wrappers.h task.h queue.h croutine.h timers.h StackMacros.h portable.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4e
    ../../../../../../common/services/clock/sam4e/: sysclk.c pll.h sysclk.h genclk.h osc.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c exceptions.h system_sam4e.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../sam/utils/cmsis/sam4e/include/: sam4e.h sam4e16c.h sam4e8e.h sam4e16e.h sam4e8c.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../sam/utils/cmsis/sam4e/include/component/: rstc.h hsmci.h chipid.h pwm.h supc.h usart.h pmc.h tc.h smc.h rswdt.h afec.h rtc.h gmac.h can.h dacc.h aes.h twi.h efc.h pdc.h rtt.h matrix.h spi.h pio.h udp.h gpbr.h wdt.h uart.h acc.h cmcc.h crccu.h dmac.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../sam/utils/cmsis/sam4e/include/instance/: pmc.h afec1.h rtc.h twi1.h smc.h uart0.h rstc.h wdt.h piod.h rswdt.h gmac.h crccu.h can0.h tc0.h chipid.h rtt.h dacc.h aes.h cmcc.h gpbr.h tc2.h pioe.h supc.h pioc.h can1.h usart1.h efc.h tc1.h twi0.h matrix.h hsmci.h dmac.h acc.h pioa.h pwm.h usart0.h spi.h udp.h piob.h afec0.h uart1.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e8c.h sam4e16c.h sam4e8e.h sam4e16e.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/gmac
    ../../../../../../sam/drivers/gmac/: gmac.c gmac.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/components/ethernet_phy
    ../../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../../../sam/components/ethernet_phy/ksz8051mnl/: ethernet_phy.c ethernet_phy.h
  group sam/boards/sam4e_ek
    ../../../../../../sam/boards/sam4e_ek/: led.h sam4e_ek.h
