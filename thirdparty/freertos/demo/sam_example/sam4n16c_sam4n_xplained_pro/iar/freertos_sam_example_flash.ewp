# IAR project freertos_sam_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../freertos-7.0.0/source/portable/iar/sam; ../../../../../../sam/utils/cmsis/sam4n/include; ../../../../../../sam/drivers/uart; ../../../../freertos-7.0.0/source/include; ../../../../../../sam/utils; ..; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/cmsis/sam4n/source/templates; ../../../../../../common/boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/boards/sam4n_xplained_pro; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/header_files; ../../../../../../common/utils; ../../../../../../common/utils/stdio/stdio_serial; ../..; ../../../../../../common/services/serial; ../../../../../../common/services/serial/sam_uart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ARM_MATH_CM4=true; __SAM4N16C__; BOARD=SAM4N_XPLAINED_PRO
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam4n_xplained_pro
    ../../../../../../sam/boards/sam4n_xplained_pro/: init.c led.h sam4n_xplained_pro.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../../../sam/utils/cmsis/sam4n/source/templates/: exceptions.c system_sam4n.c exceptions.h system_sam4n.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../../../sam/utils/cmsis/sam4n/include/: sam4n8a.h sam4n16b.h sam4n.h sam4n8c.h sam4n8b.h sam4n16c.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../../../sam/utils/cmsis/sam4n/include/instance/: instance_twi0.h instance_twi2.h instance_piob.h instance_uart3.h instance_uart1.h instance_rtc.h instance_rtt.h instance_tc0.h instance_dacc.h instance_adc.h instance_supc.h instance_pmc.h instance_spi.h instance_uart2.h instance_uart0.h instance_tc1.h instance_pwm.h instance_chipid.h instance_usart0.h instance_usart2.h instance_gpbr.h instance_twi1.h instance_pioa.h instance_efc.h instance_pioc.h instance_usart1.h instance_wdt.h instance_matrix.h instance_rstc.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../../../sam/utils/cmsis/sam4n/include/component/: component_spi.h component_uart.h component_efc.h component_dacc.h component_rstc.h component_rtc.h component_usart.h component_pmc.h component_rtt.h component_adc.h component_pio.h component_pdc.h component_supc.h component_tc.h component_wdt.h component_chipid.h component_gpbr.h component_pwm.h component_matrix.h component_twi.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../../../sam/utils/cmsis/sam4n/include/pio/: pio_sam4n8c.h pio_sam4n16c.h pio_sam4n16b.h pio_sam4n8a.h pio_sam4n8b.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h genclk.h sysclk.h pll.h
  group common/services/clock/sam4n
    ../../../../../../common/services/clock/sam4n/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: queue.c tasks.c list.c timers.c croutine.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: semphr.h FreeRTOS.h list.h projdefs.h mpu_wrappers.h task.h queue.h croutine.h timers.h StackMacros.h portable.h
  group thirdparty/freertos/demo/sam_example
    ../../: main.c FreeRTOSConfig.h
  group thirdparty/freertos/demo/sam_example/sam4n16c_sam4n_xplained_pro
    ../: conf_uart_serial.h conf_board.h conf_clock.h
  group thirdparty/freertos/demo/sam_example/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
