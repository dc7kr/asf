# IAR project freertos_sam_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../../common/services/serial/sam_uart; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../common/services/serial; ../../../../../../common/utils; ../..; ../../../../freertos-7.0.0/source/portable/iar/sam; ../../../../../../common/services/clock; ../../../../../../sam/boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/services/gpio; ../../../../../../sam/utils; ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../sam/boards/sam4s_ek2; ../../../../../../sam/drivers/uart; ../../../../freertos-7.0.0/source/include; ..; ../../../../../../sam/drivers/usart; ../../../../../../sam/utils/header_files; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK2; ARM_MATH_CM4=true; __SAM4SD32C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_example_sram.bin
  ILINK.IlinkOutputFile: freertos_sam_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/sram.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h pll.h genclk.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../freertos-7.0.0/source/: timers.c queue.c list.c tasks.c croutine.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../freertos-7.0.0/source/include/: semphr.h FreeRTOS.h list.h projdefs.h task.h queue.h mpu_wrappers.h croutine.h timers.h StackMacros.h portable.h
  group thirdparty/freertos/demo/sam_example
    ../../: main.c FreeRTOSConfig.h
  group thirdparty/freertos/demo/sam_example/sam4sd32c_sam4s_ek2
    ../: conf_uart_serial.h conf_board.h conf_clock.h
  group thirdparty/freertos/demo/sam_example/sam4sd32c_sam4s_ek2/iar
    ./: asf.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/boards/sam4s_ek2
    ../../../../../../sam/boards/sam4s_ek2/: init.c led.c sam4s_ek2.h led.h
  group sam/utils
    ../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../sam/utils/cmsis/sam4s/include/: sam4sa16c.h sam4s.h sam4s8c.h sam4s2a.h sam4s4b.h system_sam4s.h sam4s2b.h sam4s4a.h sam4s4c.h sam4sd16c.h sam4s2c.h sam4sd16b.h sam4s16c.h sam4sd32c.h sam4sa16b.h sam4s8b.h sam4s16b.h sam4sd32b.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s8b.h pio_sam4s4b.h pio_sam4s2c.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4sd16c.h pio_sam4s8c.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4sd16b.h pio_sam4sa16b.h pio_sam4s16c.h pio_sam4s2b.h pio_sam4sa16c.h pio_sam4s16b.h pio_sam4sd32c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_matrix.h instance_uart0.h instance_pwm.h instance_usart0.h instance_tc0.h instance_supc.h instance_crccu.h instance_efc0.h instance_twi0.h instance_uart1.h instance_gpbr.h instance_hsmci.h instance_spi.h instance_twi1.h instance_piob.h instance_pioc.h instance_efc1.h instance_smc.h instance_pioa.h instance_adc.h instance_pmc.h instance_rtc.h instance_rstc.h instance_chipid.h instance_ssc.h instance_rtt.h instance_cmcc.h instance_wdt.h instance_udp.h instance_dacc.h instance_usart1.h instance_tc1.h instance_acc.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../sam/utils/cmsis/sam4s/include/component/: component_supc.h component_acc.h component_tc.h component_ssc.h component_pmc.h component_usart.h component_smc.h component_dacc.h component_rstc.h component_rtc.h component_pdc.h component_udp.h component_chipid.h component_adc.h component_twi.h component_hsmci.h component_crccu.h component_rtt.h component_gpbr.h component_efc.h component_uart.h component_spi.h component_matrix.h component_cmcc.h component_wdt.h component_pwm.h component_pio.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h tpaste.h stringz.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
