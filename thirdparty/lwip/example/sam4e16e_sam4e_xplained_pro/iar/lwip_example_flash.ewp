# IAR project lwip_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../network; ..; ../../../../../sam/utils/preprocessor; ../../../../../sam/components/ethernet_phy/ksz8051mnl; ../../../../../sam/boards/sam4e_xplained_pro; ../../../../../sam/drivers/pmc; ../../network/httpserver_raw; ../../../../../sam/utils/header_files; ../../../../../sam/utils/fpu; ../../../lwip-1.4.0/src/include; ../../../../../common/services/serial; ../../../lwip-port-1.4.0/sam/include/netif; ../..; ../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../common/utils; ../../../../../sam/drivers/gmac; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../lwip-1.4.0/src/include/lwip; ../../../../../sam/utils/cmsis/sam4e/include; ../../../lwip-1.4.0/src/include/ipv4; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../common/services/serial/sam_uart; ../../../../../common/boards; ../../../lwip-port-1.4.0/sam/include; ../../../../../common/services/ioport; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4E16E__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: lwip_example_flash.bin
  ILINK.IlinkOutputFile: lwip_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/gmac
    ../../../../../sam/drivers/gmac/: gmac.c gmac.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../sam/utils/cmsis/sam4e/include/: sam4e16c.h sam4e.h sam4e8c.h sam4e16e.h sam4e8e.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../sam/utils/cmsis/sam4e/include/instance/: wdt.h rtt.h twi1.h dmac.h piob.h pmc.h hsmci.h acc.h rtc.h piod.h spi.h twi0.h smc.h pwm.h uart1.h gpbr.h afec0.h can1.h matrix.h chipid.h usart0.h pioc.h crccu.h efc.h uart0.h afec1.h dacc.h tc0.h can0.h supc.h gmac.h usart1.h tc2.h udp.h cmcc.h rstc.h pioa.h rswdt.h tc1.h aes.h pioe.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../sam/utils/cmsis/sam4e/include/component/: gmac.h pio.h usart.h afec.h dmac.h uart.h rtt.h chipid.h dacc.h pwm.h pdc.h gpbr.h smc.h udp.h pmc.h acc.h rtc.h hsmci.h supc.h crccu.h matrix.h spi.h rstc.h cmcc.h efc.h twi.h can.h aes.h rswdt.h wdt.h tc.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e8c.h sam4e16c.h sam4e16e.h sam4e8e.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/components/ethernet_phy
    ../../../../../sam/components/ethernet_phy/: documentation.h
  group sam/components/ethernet_phy/ksz8051mnl
    ../../../../../sam/components/ethernet_phy/ksz8051mnl/: ethernet_phy.c ethernet_phy.h
  group sam/boards/sam4e_xplained_pro
    ../../../../../sam/boards/sam4e_xplained_pro/: led.h sam4e_xplained_pro.h
  group thirdparty/lwip/lwip-1.4.0/src/core
    ../../../lwip-1.4.0/src/core/: dns.c raw.c dhcp.c memp.c netif.c lwip_timers_140.c sys.c tcp_out.c tcp_in.c udp.c pbuf.c tcp.c def.c stats.c mem.c init.c
  group thirdparty/lwip/lwip-1.4.0/src/core/ipv4
    ../../../lwip-1.4.0/src/core/ipv4/: ip.c inet.c ip_addr.c inet_chksum.c autoip.c igmp.c ip_frag.c icmp.c
  group thirdparty/lwip/lwip-1.4.0/src/api
    ../../../lwip-1.4.0/src/api/: tcpip.c sockets.c netifapi.c api_lib.c api_msg.c netbuf.c netdb.c err.c
  group thirdparty/lwip/lwip-1.4.0/src/netif
    ../../../lwip-1.4.0/src/netif/: etharp.c
  group thirdparty/lwip/lwip-1.4.0/src/include/lwip
    ../../../lwip-1.4.0/src/include/lwip/: stats.h snmp_asn1.h sockets.h debug.h tcp.h netif.h memp.h udp.h arch.h dns.h err.h netdb.h opt.h dhcp.h api.h mem.h pbuf.h timers.h sys.h snmp_msg.h tcp_impl.h netifapi.h api_msg.h raw.h tcpip.h snmp_structs.h snmp.h memp_std.h sio.h netbuf.h def.h init.h
  group thirdparty/lwip/lwip-1.4.0/src/include/ipv4/lwip
    ../../../lwip-1.4.0/src/include/ipv4/lwip/: autoip.h ip_addr.h igmp.h inet.h icmp.h ip_frag.h inet_chksum.h ip.h
  group thirdparty/lwip/lwip-1.4.0/src/include/netif
    ../../../lwip-1.4.0/src/include/netif/: ppp_oe.h etharp.h
  group thirdparty/lwip/example
    ../../: standalone_lwip_demo_sam.c lwipopts.h
  group thirdparty/lwip/example/network
    ../../network/: timer_mgt_sam.c ethernet_sam.c timer_mgt_sam.h ethernet_sam.h
  group thirdparty/lwip/example/network/httpserver_raw
    ../../network/httpserver_raw/: httpd.c fs.c fsdata.c fs.h fsdata.h httpd.h
  group thirdparty/lwip/example/sam4e16e_sam4e_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_eth.h
  group thirdparty/lwip/example/sam4e16e_sam4e_xplained_pro/iar
    ./: asf.h
  group thirdparty/lwip/lwip-port-1.4.0/sam/netif
    ../../../lwip-port-1.4.0/sam/netif/: ethernetif_sam4.c
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/arch
    ../../../lwip-port-1.4.0/sam/include/arch/: cc.h perf.h
  group thirdparty/lwip/lwip-port-1.4.0/sam/include/netif
    ../../../lwip-port-1.4.0/sam/include/netif/: ethernetif.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/sam4e
    ../../../../../common/services/clock/sam4e/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../common/boards/: board.h
