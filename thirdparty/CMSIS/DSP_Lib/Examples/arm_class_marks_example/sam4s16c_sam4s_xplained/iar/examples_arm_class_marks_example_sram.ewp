# IAR project examples_arm_class_marks_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../sam/utils; ../../../../../../../common/services/clock; ../../../../../../../sam/boards; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/boards/sam4s_xplained; ../../../../../../../common/utils; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../common/services/gpio; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_class_marks_example_sram.bin
  ILINK.IlinkOutputFile: examples_arm_class_marks_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_xplained
    ../../../../../../../sam/boards/sam4s_xplained/: led.c init.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_class_marks_example
    ../../: arm_class_marks_example_f32.c
