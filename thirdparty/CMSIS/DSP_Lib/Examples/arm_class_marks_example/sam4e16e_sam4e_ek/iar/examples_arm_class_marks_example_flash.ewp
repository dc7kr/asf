# IAR project examples_arm_class_marks_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4E16E Atmel SAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4E_EK; __SAM4E16E__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils; ../../../../../../../sam/utils/fpu; ../../../../../../../sam/boards; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../common/services/clock; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../common/utils; ../../../../../../../sam/utils/cmsis/sam4e/include; ..; ../../../../../../../sam/boards/sam4e_ek; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4E_EK; __SAM4E16E__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_class_marks_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_class_marks_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16e/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/: system_sam4e.c exceptions.c
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam4e_ek
    ../../../../../../../sam/boards/sam4e_ek/: init.c
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_class_marks_example
    ../../: arm_class_marks_example_f32.c
  group common/services/clock/sam4e
    ../../../../../../../common/services/clock/sam4e/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
