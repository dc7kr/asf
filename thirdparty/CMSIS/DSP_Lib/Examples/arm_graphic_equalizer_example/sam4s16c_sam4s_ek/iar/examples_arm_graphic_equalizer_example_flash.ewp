# IAR project examples_arm_graphic_equalizer_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../common/services/gpio; ../../../../../../../sam/boards/sam4s_ek; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/boards; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../common/services/clock; ../../../../../../../common/services/ioport; ..; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/pmc; ../../../../../../../common/utils; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../../Common/Include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_graphic_equalizer_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_graphic_equalizer_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek
    ../../../../../../../sam/boards/sam4s_ek/: init.c led.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Source
    ../../../Common/Source/: math_helper.c
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example
    ../../: arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
  group common/services/clock/sam4s
    ../../../../../../../common/services/clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
