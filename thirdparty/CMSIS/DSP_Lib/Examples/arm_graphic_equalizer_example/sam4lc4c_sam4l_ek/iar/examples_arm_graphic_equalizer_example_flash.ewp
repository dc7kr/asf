# IAR project examples_arm_graphic_equalizer_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../sam/drivers/wdt; ..; ../../../../../../../common/services/delay; ../../../../../../../sam/utils; ../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../..; ../../../../../../../sam/boards; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../../common/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../common/services/clock; ../../../../../../../common/services/ioport; ../../../../../../../sam/drivers/bpm; ../../../../../../../common/utils; ../../../Common/Include; ../../../../../../../sam/boards/sam4l_ek; ../../../../../../../sam/drivers/flashcalw; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: examples_arm_graphic_equalizer_example_flash.bin
  ILINK.IlinkOutputFile: examples_arm_graphic_equalizer_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h dfll.h
  group common/services/clock/sam4l
    ../../../../../../../common/services/clock/sam4l/: osc.c pll.c sysclk.c dfll.c genclk.h sysclk.h osc.h pll.h dfll.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group sam/drivers/bpm
    ../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/flashcalw
    ../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c exceptions.h system_sam4l.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls8a.h sam4ls4a.h sam4lc4b.h sam4ls8c.h sam4lc8a.h sam4lc4c.h sam4lc4a.h sam4lc2b.h sam4lc8b.h sam4ls4b.h sam4ls2a.h sam4ls2c.h sam4lc2c.h sam4l.h sam4lc2a.h sam4lc8c.h sam4ls4c.h sam4ls2b.h sam4ls8b.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_abdacb.h component_pm.h component_scif.h component_eic.h component_picouart.h component_aesa.h component_freqm.h component_hcache.h component_twis.h component_twim.h component_trng.h component_gloc.h component_chipid.h component_spi.h component_pdca.h component_smap.h component_tc.h component_ast.h component_wdt.h component_flashcalw.h component_gpio.h component_iisc.h component_crccu.h component_dacc.h component_parc.h component_bpm.h component_lcdca.h component_usbc.h component_adcife.h component_acifc.h component_usart.h component_pevc.h component_catb.h component_hmatrixb.h component_bscif.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc4c.h pio_sam4ls4c.h pio_sam4ls8a.h pio_sam4ls8c.h pio_sam4lc2b.h pio_sam4lc2a.h pio_sam4ls4a.h pio_sam4lc8b.h pio_sam4ls2a.h pio_sam4lc2c.h pio_sam4ls2b.h pio_sam4lc8a.h pio_sam4lc8c.h pio_sam4lc4b.h pio_sam4ls4b.h pio_sam4ls8b.h pio_sam4ls2c.h pio_sam4lc4a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_iisc.h instance_chipid.h instance_crccu.h instance_gpio.h instance_pm.h instance_wdt.h instance_freqm.h instance_twis1.h instance_dacc.h instance_twis0.h instance_pdca.h instance_aesa.h instance_picouart.h instance_parc.h instance_abdacb.h instance_trng.h instance_bpm.h instance_twim3.h instance_usart1.h instance_usbc.h instance_pevc.h instance_hmatrix.h instance_usart2.h instance_usart3.h instance_twim1.h instance_scif.h instance_catb.h instance_eic.h instance_adcife.h instance_tc1.h instance_twim2.h instance_hcache.h instance_twim0.h instance_gloc.h instance_usart0.h instance_lcdca.h instance_hflashc.h instance_spi.h instance_acifc.h instance_bscif.h instance_ast.h instance_tc0.h instance_smap.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: mrepeat.h stringz.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_ek
    ../../../../../../../sam/boards/sam4l_ek/: init.c board_monitor.c led.h sam4l_ek.h board_monitor.h
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Source
    ../../../Common/Source/: math_helper.c
  group thirdparty/CMSIS/DSP_Lib/Examples/Common/Include
    ../../../Common/Include/: math_helper.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example
    ../../: arm_graphic_equalizer_example_q31.c arm_graphic_equalizer_data.c documentation.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/sam4lc4c_sam4l_ek
    ../: conf_clock.h conf_board.h
  group thirdparty/CMSIS/DSP_Lib/Examples/arm_graphic_equalizer_example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
