# IAR project serial_bridge_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default  None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0=true; USART_CALLBACK_MODE=false; __SAMD20J18__; BOARD=SAMD20_XPLAINED_PRO
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../../sam0/drivers/port; ..; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../../sam0/utils/cmsis/samd20/source; ../../../../../../../common2/services/delay; ../../../../../../../sam0/utils; ../../../../../../../sam0/utils/cmsis/samd20/include/component; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../common/services/serial; ../../..; ../../../../../../../common/utils; ../../../../sio2ncp/uart; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../../sam0/drivers/system/interrupt; ../../../../sio2host/uart; ../../../../../../../common2/services/delay/sam0; ../../../../../../../sam0/utils/cmsis/samd20/include/pio; ../../../../../../../common/boards; ../../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/utils/cmsis/samd20/include/instance; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: serial_bridge_example_flash.bin
  ILINK.IlinkOutputFile: serial_bridge_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/quick_start
    ../../../../../../../sam0/drivers/system/interrupt/quick_start/: qs_system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../../sam0/drivers/system/clock/clock_samd20/: gclk.c clock.c clock_config_check.h
  group sam0/drivers/system/clock/quick_start_gclk
    ../../../../../../../sam0/drivers/system/clock/quick_start_gclk/: qs_gclk_basic.h
  group sam0/drivers/system/clock/quick_start_clock
    ../../../../../../../sam0/drivers/system/clock/quick_start_clock/: qs_clock_source.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom_interrupt.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../sam0/utils/cmsis/samd20/include/: samd20e16.h samd20g17.h samd20g15.h samd20j18.h samd20e14.h samd20g16.h samd20g14.h samd20.h samd20g18.h samd20j14.h samd20j16.h samd20e17.h samd20j15.h samd20e15.h samd20j17.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../sam0/utils/cmsis/samd20/include/instance/: instance_pac2.h instance_pac0.h instance_sercom1.h instance_sercom3.h instance_sercom5.h instance_sercom0.h instance_nvmctrl.h instance_ac.h instance_sercom2.h instance_pac1.h instance_dsu.h instance_dac.h instance_pm.h instance_sercom4.h instance_tc5.h instance_port.h instance_tc3.h instance_gclk.h instance_tc1.h instance_wdt.h instance_tc7.h instance_eic.h instance_tc4.h instance_rtc.h instance_adc.h instance_sysctrl.h instance_tc2.h instance_evsys.h instance_tc0.h instance_tc6.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../sam0/utils/cmsis/samd20/include/pio/: pio_samd20j18.h pio_samd20g15.h pio_samd20j15.h pio_samd20e17.h pio_samd20e15.h pio_samd20j16.h pio_samd20g14.h pio_samd20g17.h pio_samd20g16.h pio_samd20e16.h pio_samd20j17.h pio_samd20e14.h pio_samd20j14.h pio_samd20e1f.h pio_samd20g18.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../sam0/utils/cmsis/samd20/include/component/: component_eic.h component_ac.h component_gclk.h component_dac.h component_evsys.h component_sysctrl.h component_port.h component_dsu.h component_rtc.h component_pac.h component_sercom.h component_pm.h component_nvmctrl.h component_wdt.h component_tc.h component_adc.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../sio2host/uart/: sio2host.c sio2host.h
  group thirdparty/wireless/addons/serial_bridge
    ../../../: serial_bridge.c serial_bridge.h
  group thirdparty/wireless/addons/serial_bridge/example
    ../../: main.c
  group thirdparty/wireless/addons/serial_bridge/example/samd20j18_samd20_xplained_pro
    ../: conf_sio2host.h conf_board.h conf_clocks.h conf_sio2ncp.h
  group thirdparty/wireless/addons/serial_bridge/example/samd20j18_samd20_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../sio2ncp/uart/: sio2ncp.c sio2ncp.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
  group common2/services/delay
    ../../../../../../../common2/services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../../common2/services/delay/sam0/: cycle_counter.c cycle_counter.h
