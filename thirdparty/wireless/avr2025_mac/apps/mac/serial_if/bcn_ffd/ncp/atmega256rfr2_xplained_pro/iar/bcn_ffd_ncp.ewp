# IAR project bcn_ffd_ncp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: FFD; SAL_TYPE=ATMEGARF_SAL; TEST_HARNESS; STB_ON_SAL; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; GTS_SUPPORT; BOARD=ATMEGA256RFR2_XPLAINED_PRO; BEACON_SUPPORT; TAL_TYPE=ATMEGARFR2
  ICCAVR.newCCIncludePaths: ../../../../../../../source/mac/inc; ../../../../../../../../../../mega/utils/preprocessor; ../../../../../../../../../../mega/utils; ..; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../source/resources/queue/inc; ../../../../../../../../../../mega/drivers/usart; ../../../../../../../include; ../../../../../../../../addons/sio2host/uart; ../../../../../../../source/stb/inc; ../../../../../../../source/sal/inc; ../..; ../../../../../../../../../../common/services/serial; ../../../../../../../../../../common/services/clock; ../../../../../../../source/resources/buffer/inc; ../../../../../../../../../../common/utils; ../../../../../../../source/tal/atmegarfr2/inc; ../../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../../../mega/drivers/cpu; ../../../../../../../addons/serial_if/inc; ../../../../../../../source/pal/mega/drivers/tc; ../../../../../../../../../../mega/boards; ../../../../../../../source/pal/common_hw_timer/mega; ../../../../../../../../../../common/services/serial/megarf_usart; ../../../../../../../source/tal/inc; ../../../../../../../source/pal; ../../../../../../../../../../common/services/gpio; ../../../../../../../source/pal/common_hw_timer; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../common/boards; ../../../../../../../../../../common/services/ioport; ../../../../../../../../../../mega/boards/atmega256rfr2_xplained_pro; ../../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; SAL_TYPE=ATMEGARF_SAL; TEST_HARNESS; STB_ON_SAL; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; GTS_SUPPORT; BOARD=ATMEGA256RFR2_XPLAINED_PRO; BEACON_SUPPORT; TAL_TYPE=ATMEGARFR2
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../../../source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega
    ../../../../../../../source/pal/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega/lib
    ../../../../../../../source/pal/common_hw_timer/mega/lib/: megarfr2_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/mega/drivers/tc
    ../../../../../../../source/pal/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../source/mac/src/: mac_beacon.c mac_security.c mac_associate.c mac_scan.c mac_pib.c mac_orphan.c mac.c mac_start.c mac_poll.c mac_sync.c mac_rx_enable.c mac_gts.c mac_callback_wrapper.c mac_dispatcher.c mac_data_ind.c mac_data_extract_mhr.c mac_disassociate.c mac_misc.c mac_data_req.c mac_process_tal_tx_frame_status.c mac_tx_coord_realignment_command.c mac_api.c mac_process_beacon_frame.c mac_mcps_data.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../source/mac/inc/: mac_config.h mac_security.h mac_internal.h mac_api.h mac_data_structures.h mac_msg_type_data_ind.h mac_msg_types.h mac_msg_const.h mac.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../../../source/tal/atmegarfr2/src/: tal_slotted_csma.c tal_ed.c tal_init.c tal_rx.c tal_rx_enable.c tal_pwr_mgmt.c tal_pib.c tal_tx.c tal.c tal_irq_handler.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/inc
    ../../../../../../../source/tal/atmegarfr2/inc/: tal_pib.h tal_internal.h atmega256rfr2.h tal_constants.h tal_config.h tal_tx.h tal_rx.h tal_slotted_csma.h tal_irq_handler.h
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../source/tal/inc/: tal_types.h tal.h tal_generic.h tal_helper.h tal_timer_config.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/sal/atmegarf_sal/src
    ../../../../../../../source/sal/atmegarf_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../source/sal/inc/: sal.h sal_generic.h sal_types.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../source/stb/src/: stb.c stb_help.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/addons/serial_if/src
    ../../../../../../../addons/serial_if/src/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/addons/serial_if/inc
    ../../../../../../../addons/serial_if/inc/: private_const.h serial_interface.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if
    ../../../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_ffd/ncp
    ../../: app_config.h conf_pal.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_ffd/ncp/atmega256rfr2_xplained_pro
    ../: conf_sio2host.h conf_clock.h conf_hw_timer.h conf_board.h conf_usart_serial.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_ffd/ncp/atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../include/: avr2025_mac.h ieee_const.h mac_build_config.h return_val.h stack_config.h tal_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group common/services/clock
    ../../../../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/gpio
    ../../../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/ioport
    ../../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../../../../common/services/ioport/mega/: ioport.h
  group common/services/delay
    ../../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/utils
    ../../../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c atmega256rfr2_xplained_pro.h led.h
  group mega/drivers/usart
    ../../../../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../../../../../../mega/utils/: compiler.h status_codes.h progmem.h assembler.h
  group mega/utils/preprocessor
    ../../../../../../../../../../mega/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group mega/utils/assembler
    ../../../../../../../../../../mega/utils/assembler/: iar.h
