# IAR project bcn_ffd_ncp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: FFD; TEST_HARNESS; STB_ON_SAL; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; GTS_SUPPORT; TAL_TYPE=AT86RF212; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; BEACON_SUPPORT; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../source/mac/inc; ../../../../../../../../../../xmega/drivers/pmic; ../../../../../../../../../../common/services/spi/xmega_spi; ../../../../../../../../../../xmega/drivers/tc; ../../../../../../../../../../xmega/utils; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../source/resources/queue/inc; ../../../../../../../../services/trx_access; ../../../../../../../include; ../../../../../../../source/stb/inc; ../../../../../../../source/sal/inc; ../..; ../../../../../../../../../../common/services/gpio; ../../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../addons/sio2host/usb; ../../../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../../common/utils; ../../../../../../../../../../common/services/usb/class/cdc; ../../../../../../../addons/serial_if/inc; ../../../../../../../../../../common/services/clock; ../../../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../source/resources/buffer/inc; ../../../../../../../../../../common/services/usb; ../../../../../../../source/tal/at86rf212/inc; ../../../../../../../../../../xmega/boards; ../../../../../../../../../../xmega/drivers/sleep; ../../../../../../../source/tal/inc; ../../../../../../../source/pal; ../../../../../../../../services/common_hw_timer/xmega; ../../../../../../../../../../common/services/delay; ../../../../../../../../../../common/services/usb/udc; ../../../../../../../../../../xmega/drivers/usb; ..; ../../../../../../../../../../common/boards; ../../../../../../../../../../xmega/drivers/spi; ../../../../../../../../../../common/services/ioport; ../../../..; ../../../../../../../../../../xmega/drivers/cpu; ../../../../../../../../../../common/services/spi; ../../../../../../../../services/common_hw_timer; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; TEST_HARNESS; STB_ON_SAL; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; GTS_SUPPORT; TAL_TYPE=AT86RF212; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT; BEACON_SUPPORT; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega
    ../../../../../../../../services/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega/lib
    ../../../../../../../../services/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/services/trx_access
    ../../../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../source/mac/src/: mac_pib.c mac_beacon.c mac_associate.c mac_scan.c mac_poll.c mac_rx_enable.c mac_data_ind.c mac_gts.c mac_orphan.c mac.c mac_start.c mac_data_extract_mhr.c mac_sync.c mac_misc.c mac_dispatcher.c mac_callback_wrapper.c mac_disassociate.c mac_security.c mac_api.c mac_data_req.c mac_process_tal_tx_frame_status.c mac_tx_coord_realignment_command.c mac_mcps_data.c mac_process_beacon_frame.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../source/mac/inc/: mac_config.h mac_internal.h mac_api.h mac_msg_type_data_ind.h mac_msg_types.h mac_msg_const.h mac_security.h mac_data_structures.h mac.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/src
    ../../../../../../../source/tal/at86rf212/src/: tal_slotted_csma.c tal_rx_enable.c tal_irq_handler.c tal_init.c tal_tx.c tal.c tal_pib.c tal_ed.c tal_rx.c tal_pwr_mgmt.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/inc
    ../../../../../../../source/tal/at86rf212/inc/: tal_irq_handler.h tal_slotted_csma.h tal_rx.h tal_constants.h tal_pib.h tal_tx.h tal_config.h at86rf212.h tal_internal.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../source/tal/inc/: tal.h tal_helper.h tal_timer_config.h tal_types.h tal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../source/pal/: pal.c pal_ext_trx.c pal_generic.h pal.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/sal/atxmega_sal/src
    ../../../../../../../source/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../source/sal/inc/: sal_generic.h sal_types.h sal.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../source/stb/src/: stb_help.c stb.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../source/stb/inc/: stb_armcrypto.h stb_internal.h stb.h stb_generic.h
  group thirdparty/wireless/avr2025_mac/addons/serial_if/src
    ../../../../../../../addons/serial_if/src/: serial_interface.c
  group thirdparty/wireless/avr2025_mac/addons/serial_if/inc
    ../../../../../../../addons/serial_if/inc/: private_const.h serial_interface.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if
    ../../../../: main.c conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_ffd/ncp
    ../../: app_config.h conf_trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_ffd/ncp/xmega_a3bu_xplained_rz600rf212
    ../: conf_sio2host.h conf_board.h conf_clock.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/serial_if/bcn_ffd/ncp/xmega_a3bu_xplained_rz600rf212/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../include/: avr2025_mac.h stack_config.h ieee_const.h return_val.h tal_build_config.h mac_build_config.h
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../../../addons/sio2host/usb/: sio2host.c sio2host.h
  group common/services/spi
    ../../../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/usb
    ../../../../../../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/class/cdc
    ../../../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc.h udi_cdc_conf.h
  group common/services/usb/udc
    ../../../../../../../../../../common/services/usb/udc/: udc.c udi.h udc.h udc_desc.h udd.h
  group common/services/sleepmgr
    ../../../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/clock
    ../../../../../../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/xmega
    ../../../../../../../../../../common/services/clock/xmega/: sysclk.c osc.h pll.h sysclk.h
  group common/services/delay
    ../../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/services/gpio
    ../../../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/utils
    ../../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
  group xmega/drivers/spi
    ../../../../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/tc
    ../../../../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/usb
    ../../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/nvm
    ../../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/cpu
    ../../../../../../../../../../xmega/drivers/cpu/: ccp.s ccp.h xmega_reset_cause.h
  group xmega/drivers/pmic
    ../../../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/drivers/sleep
    ../../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/utils
    ../../../../../../../../../../xmega/utils/: assembler.h compiler.h progmem.h status_codes.h
  group xmega/utils/bit_handling
    ../../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/preprocessor
    ../../../../../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h stringz.h mrepeat.h
  group xmega/utils/assembler
    ../../../../../../../../../../xmega/utils/assembler/: iar.h
