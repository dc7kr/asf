# IAR project mac_no_beacon_sleep.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: FFD; STB_ON_SAL; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; TAL_TYPE=AT86RF212; SAL_TYPE=AT86RF2xx; BOARD=RZ600; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ../../../../../source/mac/inc; ../../../../../../../../avr32/boards; ../../../../../../../../common/services/spi/uc3_spi; ../../../../../source/pal/common_sw_timer; ../../../../../../../../avr32/drivers/pm; ../../../../../source/resources/queue/inc; ..; ../../../../../../services/trx_access; ../../../../../include; ../../../../../../services/common_hw_timer/uc3; ../../../../../source/stb/inc; ../../../../../source/sal/inc; ../../../../../../../../avr32/drivers/tc; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/drivers/gpio; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../../../../avr32/boards/rz600; ../../../../../../../../avr32/drivers/spi; ../../../../../../../../common/services/clock; ../../../../../source/resources/buffer/inc; ../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../source/tal/at86rf212/inc; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common/services/delay; ../../../../../../../../common/services/spi; ../../../../../../../../common/boards; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../common/services/ioport; ../../../../../../../../avr32/utils/preprocessor; ../../../../../../services/common_hw_timer; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/uc3
    ../../../../../../services/common_hw_timer/uc3/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/uc3/lib
    ../../../../../../services/common_hw_timer/uc3/lib/: uc3_lib_hw_timer.r82
  group thirdparty/wireless/services/trx_access
    ../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal_ext_trx.c pal.h pal_generic.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../source/mac/src/: mac_tx_coord_realignment_command.c mac_poll.c mac_api.c mac_associate.c mac_data_extract_mhr.c mac_callback_wrapper.c mac_beacon.c mac_scan.c mac_data_req.c mac_gts.c mac_disassociate.c mac_data_ind.c mac_process_beacon_frame.c mac_security.c mac_start.c mac_orphan.c mac_mcps_data.c mac_pib.c mac_sync.c mac_dispatcher.c mac_process_tal_tx_frame_status.c mac.c mac_misc.c mac_rx_enable.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac_msg_type_data_ind.h mac_data_structures.h mac_internal.h mac_security.h mac_api.h mac_config.h mac_msg_const.h mac.h mac_msg_types.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../source/stb/src/: stb_armcrypto.c stb_help.c stb.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../source/stb/inc/: stb.h stb_generic.h stb_armcrypto.h stb_internal.h
  group thirdparty/wireless/avr2025_mac/source/sal/at86rf2xx/src
    ../../../../../source/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../source/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/src
    ../../../../../source/tal/at86rf212/src/: tal_tx.c tal_init.c tal_pwr_mgmt.c tal_irq_handler.c tal.c tal_slotted_csma.c tal_rx.c tal_rx_enable.c tal_ed.c tal_pib.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/inc
    ../../../../../source/tal/at86rf212/inc/: tal_pib.h tal_irq_handler.h tal_rx.h tal_tx.h tal_slotted_csma.h tal_internal.h at86rf212.h tal_config.h tal_constants.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal_types.h tal_timer_config.h tal_generic.h tal.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep
    ../../: main.c app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep/at32uc3a3256s_rz600_at86rf212
    ../: conf_clock.h conf_board.h conf_spi_master.h conf_sleepmgr.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep/at32uc3a3256s_rz600_at86rf212/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: avr2025_mac.h mac_build_config.h return_val.h stack_config.h ieee_const.h tal_build_config.h
  group avr32/drivers/pm
    ../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c pm.c power_clocks_lib.c pm.h sleep.h power_clocks_lib.h
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/tc
    ../../../../../../../../avr32/drivers/tc/: tc.c tc.h
  group avr32/drivers/spi
    ../../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/rz600
    ../../../../../../../../avr32/boards/rz600/: led.c init.c rz600.h led.h
  group avr32/utils
    ../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../avr32/utils/preprocessor/: mrepeat.h tpaste.h preprocessor.h stringz.h
  group avr32/utils/header_files
    ../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c sysclk.h pll.h genclk.h osc.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../../../common/services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../../../common/services/ioport/uc3/: ioport.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
