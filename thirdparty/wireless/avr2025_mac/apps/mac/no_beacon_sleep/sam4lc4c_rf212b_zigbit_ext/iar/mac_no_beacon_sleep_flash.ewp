# IAR project mac_no_beacon_sleep_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FFD; STB_ON_SAL; BOARD=SAM4L_XPLAINED_PRO; __SAM4LC4C__; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; SAL_TYPE=AT86RF2xx; TAL_TYPE=AT86RF212B; DISABLE_TSTAMP_IRQ=1; ARM_MATH_CM4=true; PAL_USE_SPI_TRX=1
  ICCARM.CCIncludePath2: ../..; ../../../../../source/mac/inc; ../../../../../../../../common/services/spi/sam_spi; ../../../../../../../../common/boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../source/pal/common_sw_timer; ..; ../../../../../source/resources/queue/inc; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../include; ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../source/stb/inc; ../../../../../source/sal/inc; ../../../../../../../../sam/drivers/spi; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../source/resources/buffer/inc; ../../../../../source/tal/at86rf212b/inc; ../../../../../source/pal; ../../../../../source/pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../source/tal/inc; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/tc; ../../../../../../../../common/services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/bpm; ../../../../../source/pal/common_hw_timer/sam; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mac_no_beacon_sleep_flash.bin
  ILINK.IlinkOutputFile: mac_no_beacon_sleep_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal_ext_trx.c pal.h pal_generic.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../source/pal/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../source/mac/src/: mac_gts.c mac_start.c mac_poll.c mac_api.c mac_disassociate.c mac_associate.c mac_data_extract_mhr.c mac_beacon.c mac_data_req.c mac_scan.c mac_data_ind.c mac_process_beacon_frame.c mac_security.c mac_tx_coord_realignment_command.c mac_orphan.c mac_mcps_data.c mac_pib.c mac_sync.c mac_rx_enable.c mac_process_tal_tx_frame_status.c mac_dispatcher.c mac.c mac_callback_wrapper.c mac_misc.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac_data_structures.h mac_internal.h mac_security.h mac.h mac_msg_types.h mac_api.h mac_msg_const.h mac_msg_type_data_ind.h mac_config.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../source/stb/src/: stb_armcrypto.c stb.c stb_help.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../source/stb/inc/: stb.h stb_generic.h stb_internal.h stb_armcrypto.h
  group thirdparty/wireless/avr2025_mac/source/sal/at86rf2xx/src
    ../../../../../source/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../source/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/src
    ../../../../../source/tal/at86rf212b/src/: tal.c tal_init.c tal_rx_enable.c tal_tx.c tal_irq_handler.c tal_pwr_mgmt.c tal_ed.c tal_rx.c tal_slotted_csma.c tal_pib.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/inc
    ../../../../../source/tal/at86rf212b/inc/: tal_slotted_csma.h tal_rx.h tal_irq_handler.h at86rf212b.h tal_internal.h tal_config.h tal_constants.h tal_pib.h tal_tx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal_types.h tal_timer_config.h tal_generic.h tal.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep
    ../../: main.c app_config.h conf_pal.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep/sam4lc4c_rf212b_zigbit_ext
    ../: conf_clock.h conf_board.h conf_spi_master.h conf_sleepmgr.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon_sleep/sam4lc4c_rf212b_zigbit_ext/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: avr2025_mac.h mac_build_config.h return_val.h ieee_const.h tal_build_config.h stack_config.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h dfll.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../../../common/services/clock/sam4l/: sysclk.c dfll.c osc.c pll.c genclk.h sysclk.h osc.h dfll.h pll.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../../common/services/sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls4b.h sam4lc8b.h sam4lc4c.h sam4lc4a.h sam4ls2a.h sam4l.h sam4lc2a.h sam4lc2c.h sam4ls4a.h sam4ls2c.h sam4ls8c.h sam4lc8c.h sam4ls4c.h sam4lc4b.h sam4lc2b.h sam4ls8a.h sam4ls2b.h sam4ls8b.h sam4lc8a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_tc1.h instance_acifc.h instance_hflashc.h instance_freqm.h instance_eic.h instance_pm.h instance_chipid.h instance_usart2.h instance_bpm.h instance_trng.h instance_smap.h instance_abdacb.h instance_aesa.h instance_catb.h instance_twis0.h instance_parc.h instance_wdt.h instance_twim0.h instance_ast.h instance_usart0.h instance_crccu.h instance_usart3.h instance_bscif.h instance_gpio.h instance_twim2.h instance_scif.h instance_adcife.h instance_lcdca.h instance_gloc.h instance_twis1.h instance_pevc.h instance_iisc.h instance_twim1.h instance_usart1.h instance_hcache.h instance_tc0.h instance_twim3.h instance_spi.h instance_picouart.h instance_dacc.h instance_pdca.h instance_hmatrix.h instance_usbc.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc8c.h pio_sam4lc2b.h pio_sam4lc8a.h pio_sam4lc8b.h pio_sam4lc4a.h pio_sam4lc4c.h pio_sam4ls8a.h pio_sam4ls4b.h pio_sam4ls8c.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4ls4c.h pio_sam4ls2a.h pio_sam4lc4b.h pio_sam4lc2c.h pio_sam4lc2a.h pio_sam4ls8b.h pio_sam4ls2b.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_flashcalw.h component_freqm.h component_parc.h component_abdacb.h component_usbc.h component_adcife.h component_lcdca.h component_iisc.h component_gloc.h component_twis.h component_spi.h component_twim.h component_hmatrixb.h component_crccu.h component_ast.h component_gpio.h component_bscif.h component_bpm.h component_eic.h component_usart.h component_trng.h component_hcache.h component_tc.h component_scif.h component_pdca.h component_picouart.h component_pm.h component_dacc.h component_smap.h component_pevc.h component_aesa.h component_catb.h component_acifc.h component_chipid.h component_wdt.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
