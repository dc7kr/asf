# IAR project dev_ncp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x300
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: STB_ON_SAL; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; SAL_TYPE=ATMEGARF_SAL; BOARD=ATMEGA256RFR2_XPLAINED_PRO; SIO_HUB; TAL_TYPE=ATMEGARFR2
  ICCAVR.newCCIncludePaths: ../..; ../../..; ../../../../../../../source/mac/inc; ../../../../../../../../../../mega/utils/preprocessor; ../../../../../../../../../../mega/utils; ../../../../../../../source/pal/common_sw_timer; ../../../../../../../source/resources/queue/inc; ../../../../../../../../../../mega/drivers/usart; ../../../../../../../include; ../../../../../../../../addons/sio2host/uart; ../../../../../../../source/stb/inc; ../../../../../../../source/sal/inc; ../../../../../../../../../../common/services/serial; ../../../../../../../source/resources/buffer/inc; ../../../../../../../../../../common/utils; ../../../../../../../source/tal/atmegarfr2/inc; ../../../../../../../../../../mega/drivers/cpu; ../../../../../../../../../../common/services/clock; ../../../../../../../../../../mega/boards; ../../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../services/common_hw_timer/mega; ../../../../../../../../../../common/services/delay; ../../../../../../../../services/common_hw_timer; ..; ../../../../../../../source/tal/inc; ../../../../../../../source/pal; ../../../../../../../../../../common/services/gpio; ../../../../../../../../../../common/services/serial/megarf_usart; ../../../../../../../../../../common/boards; ../../../../../../../../../../common/services/ioport; ../../../../../../../../services/mega/drivers/tc; ../../../../../../../../../../mega/boards/atmega256rfr2_xplained_pro; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; STB_ON_SAL; HIGHEST_STACK_LAYER=MAC; ENABLE_TSTAMP; SAL_TYPE=ATMEGARF_SAL; BOARD=ATMEGA256RFR2_XPLAINED_PRO; SIO_HUB; TAL_TYPE=ATMEGARFR2
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega
    ../../../../../../../../services/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega/lib
    ../../../../../../../../services/common_hw_timer/mega/lib/: megarfr2_lib_hw_timer.r90
  group thirdparty/wireless/services/mega/drivers/tc
    ../../../../../../../../services/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../source/mac/src/: mac_pib.c mac_beacon.c mac_security.c mac_associate.c mac_scan.c mac_poll.c mac_orphan.c mac.c mac_start.c mac_sync.c mac_gts.c mac_rx_enable.c mac_callback_wrapper.c mac_dispatcher.c mac_data_ind.c mac_data_extract_mhr.c mac_disassociate.c mac_misc.c mac_api.c mac_data_req.c mac_process_tal_tx_frame_status.c mac_tx_coord_realignment_command.c mac_mcps_data.c mac_process_beacon_frame.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../source/mac/inc/: mac_config.h mac.h mac_internal.h mac_api.h mac_data_structures.h mac_msg_type_data_ind.h mac_msg_types.h mac_msg_const.h mac_security.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../../../source/tal/atmegarfr2/src/: tal_slotted_csma.c tal_ed.c tal_init.c tal_rx.c tal_rx_enable.c tal_pwr_mgmt.c tal_pib.c tal_tx.c tal.c tal_irq_handler.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/inc
    ../../../../../../../source/tal/atmegarfr2/inc/: tal_pib.h tal_internal.h atmega256rfr2.h tal_constants.h tal_config.h tal_tx.h tal_rx.h tal_slotted_csma.h tal_irq_handler.h
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../source/tal/inc/: tal_types.h tal.h tal_generic.h tal_helper.h tal_timer_config.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/sal/atmegarf_sal/src
    ../../../../../../../source/sal/atmegarf_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../source/sal/inc/: sal_generic.h sal.h sal_types.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../source/stb/src/: stb.c stb_help.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon/dev
    ../../../: main.c app_security.c beacon_app.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon/dev/ncp
    ../../: conf_common_sw_timer.h app_config.h conf_trx_access.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon/dev/ncp/atmega256rfr2_xplained_pro
    ../: conf_sio2host.h conf_hw_timer.h conf_board.h conf_usart_serial.h conf_clock.h
  group thirdparty/wireless/avr2025_mac/apps/mac/no_beacon/dev/ncp/atmega256rfr2_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../include/: avr2025_mac.h ieee_const.h mac_build_config.h return_val.h stack_config.h tal_build_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group common/services/clock
    ../../../../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/serial
    ../../../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/gpio
    ../../../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/ioport
    ../../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../../../../common/services/ioport/mega/: ioport.h
  group common/services/delay
    ../../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/utils
    ../../../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../../../common/boards/: board.h
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../../../../../../mega/boards/atmega256rfr2_xplained_pro/: init.c led.h atmega256rfr2_xplained_pro.h
  group mega/drivers/usart
    ../../../../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../../../../../../mega/utils/: compiler.h status_codes.h progmem.h assembler.h
  group mega/utils/preprocessor
    ../../../../../../../../../../mega/utils/preprocessor/: mrepeat.h stringz.h preprocessor.h tpaste.h
  group mega/utils/assembler
    ../../../../../../../../../../mega/utils/assembler/: iar.h
