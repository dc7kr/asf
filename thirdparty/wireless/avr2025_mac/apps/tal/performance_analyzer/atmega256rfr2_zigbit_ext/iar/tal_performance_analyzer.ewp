# IAR project tal_performance_analyzer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: FFD; ENABLE_TFA; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; TAL_TYPE=ATMEGARFR2; BOARD=ATMEGA256RFR2_ZIGBIT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../source/mac/inc; ../../../../../../../../mega/utils/preprocessor; ../../../../../../../../mega/utils; ../../../../../source/pal/common_sw_timer; ../../../../../source/resources/queue/inc; ../../../../../../../../mega/drivers/usart; ../../../../../include; ../../../../../../addons/sio2host/uart; ../..; ../../../../../../../../common/services/serial; ../../../../../../../../common/services/ioport; ../../../../../../../../common/services/clock; ../../../../../source/tfa/inc; ..; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../source/tal/atmegarfr2/inc; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../mega/drivers/cpu; ../../../../../source/pal/mega/drivers/tc; ../../../../../../../../mega/boards; ../../../../../source/pal/common_hw_timer/mega; ../../../../../../../../common/services/serial/megarf_usart; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common/services/gpio; ../../../../../../../../mega/boards/atmega256rfr2_zigbit; ../../../../../source/pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../../../../common/boards; ../../inc; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; ENABLE_TFA; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; TAL_TYPE=ATMEGARFR2; BOARD=ATMEGA256RFR2_ZIGBIT
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega
    ../../../../../source/pal/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/mega/lib
    ../../../../../source/pal/common_hw_timer/mega/lib/: megarfr2_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/mega/drivers/tc
    ../../../../../source/pal/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../source/tal/atmegarfr2/src/: tal_pib.c tal_irq_handler.c tal.c tal_tx.c tal_pwr_mgmt.c tal_ed.c tal_init.c tal_rx_enable.c tal_rx.c tal_slotted_csma.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/inc
    ../../../../../source/tal/atmegarfr2/inc/: tal_slotted_csma.h tal_irq_handler.h atmega256rfr2.h tal_internal.h tal_tx.h tal_constants.h tal_pib.h tal_config.h tal_rx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../source/tal/inc/: tal.h tal_generic.h tal_timer_config.h tal_types.h tal_helper.h
  group thirdparty/wireless/avr2025_mac/source/tfa/atmegarfr2/src
    ../../../../../source/tfa/atmegarfr2/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../../../source/tfa/inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../source/mac/inc/: mac.h mac_msg_type_data_ind.h mac_msg_types.h mac_api.h mac_config.h mac_msg_const.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer
    ../../: conf_common_sw_timer.h conf_pal.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c user_interface.c per_mode_receptor.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c init_state.c peer_search_initiator.c main.c wait_for_event.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/atmega256rfr2_zigbit_ext
    ../: conf_usart_serial.h conf_sio2host.h conf_clock.h conf_hw_timer.h conf_board.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/atmega256rfr2_zigbit_ext/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/inc
    ../../inc/: perf_api_serial_handler.h app_config.h app_per_mode.h user_interface.h app_init.h app_frame_format.h perf_msg_const.h app_peer_search.h app_range_mode.h perf_api.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: tal_build_config.h ieee_const.h avr2025_mac.h return_val.h mac_build_config.h stack_config.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/megarf_usart
    ../../../../../../../../common/services/serial/megarf_usart/: usart_serial.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../../common/services/ioport/mega/: ioport.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group mega/boards/atmega256rfr2_zigbit
    ../../../../../../../../mega/boards/atmega256rfr2_zigbit/: init.c led.h atmega256rfr2_zigbit.h
  group mega/drivers/usart
    ../../../../../../../../mega/drivers/usart/: usart_megarf.c usart_megarf.h
  group mega/drivers/cpu
    ../../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
  group mega/utils
    ../../../../../../../../mega/utils/: progmem.h status_codes.h assembler.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../../../mega/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group mega/utils/assembler
    ../../../../../../../../mega/utils/assembler/: iar.h
