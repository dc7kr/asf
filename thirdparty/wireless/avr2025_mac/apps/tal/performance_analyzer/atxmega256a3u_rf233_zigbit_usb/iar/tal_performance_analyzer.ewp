# IAR project tal_performance_analyzer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: FFD; ENABLE_TFA; TAL_TYPE=AT86RF233; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; IOPORT_XMEGA_COMPAT; ENABLE_DEEP_SLEEP; BOARD=XMEGA_RF233_ZIGBIT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../source/pal/common_hw_timer/xmega; ../../../../../../../../common/services/usb/class/cdc/device; ../../../../../source/mac/inc; ../../../../../../../../xmega/drivers/pmic; ../../../../../../../../common/services/spi/xmega_spi; ../../../../../../../../xmega/drivers/tc; ../../../../../../../../xmega/utils; ../../../../../source/pal/common_sw_timer; ../../../../../source/resources/queue/inc; ../../../../../include; ..; ../..; ../../../../../source/tfa/inc; ../../../../../../../../xmega/boards/xmega_rf233_zigbit; ../../../../../../addons/sio2host/usb; ../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/utils; ../../../../../source/tal/at86rf233/inc; ../../../../../../../../common/services/usb/class/cdc; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../common/services/clock; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/services/usb; ../../../../../../../../xmega/boards; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../../../../common/services/gpio; ../../../../../../../../common/services/ioport; ../../../../../source/pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../../../../common/services/usb/udc; ../../../../../../../../xmega/drivers/usb; ../../../../../../../../common/services/spi; ../../../../../../../../common/boards; ../../../../../../../../xmega/drivers/spi; ../../inc; ../../../../../../../../xmega/drivers/sleep; ../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; FFD; ENABLE_TFA; TAL_TYPE=AT86RF233; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; IOPORT_XMEGA_COMPAT; ENABLE_DEEP_SLEEP; BOARD=XMEGA_RF233_ZIGBIT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal_ext_trx.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega
    ../../../../../source/pal/common_hw_timer/xmega/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/xmega/lib
    ../../../../../source/pal/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../source/tal/at86rf233/src/: tal_init.c tal_rx_enable.c tal_rx.c tal_pib.c tal_tx.c tal_irq_handler.c tal.c tal_ed.c tal_pwr_mgmt.c tal_slotted_csma.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf233/src
    ../../../../../source/tfa/at86rf233/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c init_state.c user_interface.c wait_for_event.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c peer_search_initiator.c main.c per_mode_receptor.c
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../addons/sio2host/usb/: sio2host.c
  group common/services/ioport/xmega
    ../../../../../../../../common/services/ioport/xmega/: ioport_compat.c
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c
  group common/services/clock/xmega
    ../../../../../../../../common/services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c
  group common/services/spi/xmega_spi
    ../../../../../../../../common/services/spi/xmega_spi/: spi_master.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group xmega/drivers/spi
    ../../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/tc
    ../../../../../../../../xmega/drivers/tc/: tc.c
  group xmega/drivers/usb
    ../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_rf233_zigbit
    ../../../../../../../../xmega/boards/xmega_rf233_zigbit/: init.c
