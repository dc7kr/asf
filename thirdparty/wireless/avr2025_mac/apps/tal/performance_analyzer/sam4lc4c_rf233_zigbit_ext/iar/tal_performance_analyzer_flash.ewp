# IAR project tal_performance_analyzer_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FFD; BOARD=SAM4L_XPLAINED_PRO; ENABLE_TFA; TAL_TYPE=AT86RF233; __SAM4LC4C__; TRX_REG_RAW_VALUE; HIGHEST_STACK_LAYER=TAL; HIGH_DATA_RATE_SUPPORT; ENABLE_DEEP_SLEEP; DISABLE_TSTAMP_IRQ=1; ARM_MATH_CM4=true; PAL_USE_SPI_TRX=1
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../source/mac/inc; ../../../../../../../../common/services/spi/sam_spi; ..; ../../../../../../../../common/boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../source/pal/common_sw_timer; ../../../../../source/resources/queue/inc; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../include; ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../addons/sio2host/uart; ../..; ../../../../../../../../common/services/serial; ../../inc; ../../../../../source/tfa/inc; ../../../../../../../../sam/drivers/spi; ../../../../../source/resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../source/tal/at86rf233/inc; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../common/services/spi; ../../../../../source/tal/inc; ../../../../../source/pal; ../../../../../source/pal/common_hw_timer; ../../../../../../../../common/services/delay; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/tc; ../../../../../../../../sam/drivers/usart; ../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../common/services/ioport; ../../../../../../../../sam/drivers/bpm; ../../../../../source/pal/common_hw_timer/sam; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tal_performance_analyzer_flash.bin
  ILINK.IlinkOutputFile: tal_performance_analyzer_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../source/pal/: pal.c pal_ext_trx.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../source/pal/common_hw_timer/sam/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../source/tal/at86rf233/src/: tal_init.c tal_rx_enable.c tal_rx.c tal_pib.c tal_tx.c tal_irq_handler.c tal.c tal_ed.c tal_pwr_mgmt.c tal_slotted_csma.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf233/src
    ../../../../../source/tfa/at86rf233/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/apps/tal/performance_analyzer/src
    ../../src/: perf_api_serial_handler.c user_interface.c range_measure.c per_mode_common_utils.c peer_search_receptor.c per_mode_initiator.c init_state.c peer_search_initiator.c main.c per_mode_receptor.c wait_for_event.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../addons/sio2host/uart/: sio2host.c
  group common/services/clock/sam4l
    ../../../../../../../../common/services/clock/sam4l/: sysclk.c dfll.c osc.c pll.c
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/spi/sam_spi
    ../../../../../../../../common/services/spi/sam_spi/: spi_master.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c
