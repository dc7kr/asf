# IAR project tfa_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: FFD; ENABLE_TFA; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=TAL; UDD_ENABLE; TAL_TYPE=AT86RF212; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=RZ600; DISABLE_TSTAMP_IRQ=1; PAL_USE_SPI_TRX=1
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../common/services/usb/class/cdc/device; ../../../../mac/inc; ../../../../../../../../avr32/boards; ../../../../../../../../common/services/spi/uc3_spi; ../../../../pal/common_sw_timer; ../../../../../../../../avr32/drivers/usbb; ../../../../../../../../avr32/drivers/pm; ../../../../resources/queue/inc; ../../../../../../services/trx_access; ../../../../../include; ../../../../pal; ../../../../../../../../avr32/drivers/tc; ../../../../../../../../common/utils/stdio/stdio_usb; ../../../inc; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/drivers/gpio; ../../../../resources/buffer/inc; ../../../../../../../../common/utils; ../../../../../../../../avr32/boards/rz600; ../../../../../../../../avr32/drivers/spi; ..; ../../../../../../../../common/services/usb/class/cdc; ../../../../../../../../common/services/sleepmgr; ../../../../../../../../common/services/clock; ../..; ../../../../../../../../common/services/usb; ../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../tal/at86rf212/inc; ../../../../tal/inc; ../../../../../../services/common_hw_timer/uc3; ../../../../../../../../common/services/delay; ../../../../../../../../common/services/usb/udc; ../../../../../../../../common/services/spi; ../../../../../../../../common/boards; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../common/services/ioport; ../../../../../../../../avr32/utils/preprocessor; ../../../../../../services/common_hw_timer; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/uc3
    ../../../../../../services/common_hw_timer/uc3/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/uc3/lib
    ../../../../../../services/common_hw_timer/uc3/lib/: uc3_lib_hw_timer.r82
  group thirdparty/wireless/services/trx_access
    ../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/src
    ../../../../tal/at86rf212/src/: tal_pwr_mgmt.c tal_slotted_csma.c tal_pib.c tal_rx_enable.c tal_tx.c tal_ed.c tal_irq_handler.c tal.c tal_init.c tal_rx.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/inc
    ../../../../tal/at86rf212/inc/: tal_config.h tal_irq_handler.h at86rf212.h tal_tx.h tal_slotted_csma.h tal_constants.h tal_internal.h tal_pib.h tal_rx.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../tal/inc/: tal_generic.h tal_types.h tal_timer_config.h tal_helper.h tal.h
  group thirdparty/wireless/avr2025_mac/source/tfa/unit_tests
    ../../: unit_tests.c unit_tests.h app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2025_mac/source/tfa/unit_tests/at32uc3a3256s_rz600_at86rf212
    ../: conf_sleepmgr.h conf_clock.h conf_board.h conf_usb.h conf_spi_master.h conf_test.h conf_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/tfa/unit_tests/at32uc3a3256s_rz600_at86rf212/iar
    ./: asf.h
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf212/src
    ../../../at86rf212/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../pal/: pal.c pal_ext_trx.c pal_generic.h pal.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../mac/inc/: mac_config.h mac_msg_type_data_ind.h mac_api.h mac_msg_types.h mac_msg_const.h mac.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../include/: avr2025_mac.h mac_build_config.h return_val.h stack_config.h ieee_const.h tal_build_config.h
  group avr32/drivers/pm
    ../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c pm.c power_clocks_lib.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/usbb
    ../../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/tc
    ../../../../../../../../avr32/drivers/tc/: tc.c tc.h
  group avr32/drivers/spi
    ../../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/rz600
    ../../../../../../../../avr32/boards/rz600/: led.c init.c rz600.h led.h
  group avr32/utils
    ../../../../../../../../avr32/utils/: compiler.h status_codes.h
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/preprocessor
    ../../../../../../../../avr32/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group avr32/utils/header_files
    ../../../../../../../../avr32/utils/header_files/: uc3d_defines_fix.h uc3l3_l4_defines_fix.h
  group common/services/usb
    ../../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../../../common/services/usb/udc/: udc.c udc.h udi.h udc_desc.h udd.h
  group common/services/usb/class/cdc
    ../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc.h udi_cdc_conf.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/uc3a3_a4
    ../../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c sysclk.h pll.h genclk.h osc.h
  group common/services/spi
    ../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../../../common/services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../../../common/services/ioport/uc3/: ioport.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
