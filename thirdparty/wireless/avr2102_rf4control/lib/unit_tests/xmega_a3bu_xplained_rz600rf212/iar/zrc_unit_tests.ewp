# IAR project zrc_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: MAC_USER_BUILD_CONFIG; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; ZRC_CMD_DISCOVERY; RF4CE_TARGET; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; TAL_TYPE=AT86RF212; TEST_SUITE_DEFINE_ASSERT_MACRO; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; BOARD=XMEGA_A3BU_XPLAINED; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; SIO_HUB; RF4CE_CALLBACK_PARAM; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=RF4CE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../common/services/usb/class/cdc/device; ../../../../../avr2025_mac/source/mac/inc; ../../../../../../../xmega/drivers/pmic; ../../../../../../../common/services/spi/xmega_spi; ../../../../../../../xmega/drivers/tc; ../../../../../../../xmega/utils; ../../../../../../../common/services/usb/udc; ../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../common/drivers/nvm; ../../../../include; ../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../services/trx_access; ../../../../../avr2025_mac/include; ../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../avr2025_mac/source/stb/inc; ../../../../../avr2025_mac/source/sal/inc; ../../../../../services/common_hw_timer/xmega; ../../../../../../../common/services/ioport; ../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../xmega/drivers/nvm; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/utils; ../../../../../../../common/services/usb/class/cdc; ../../../../../../../common/services/clock; ../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../common/services/usb; ../../../../../../../common/services/delay; ../../../../../services/common_hw_timer; ../../../../../../../xmega/boards; ../../../../../avr2025_mac/source/tal/inc; ../../../../../avr2025_mac/source/pal; ../../../../../../../common/services/gpio; ../../../zrc/tgt/config; ..; ../..; ../../../../../../../xmega/drivers/usb; ../../../../../../../common/services/spi; ../../../../../../../common/boards; ../../../../../../../xmega/drivers/spi; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/drivers/sleep; ../../../../../../../xmega/drivers/cpu; ../../../../../avr2025_mac/source/tal/at86rf212/inc; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; MAC_USER_BUILD_CONFIG; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; ZRC_CMD_DISCOVERY; RF4CE_TARGET; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; TAL_TYPE=AT86RF212; TEST_SUITE_DEFINE_ASSERT_MACRO; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; BOARD=XMEGA_A3BU_XPLAINED; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; SIO_HUB; RF4CE_CALLBACK_PARAM; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=RF4CE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega
    ../../../../../services/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega/lib
    ../../../../../services/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/atxmega256a3bu/iar
    ../../../zrc/tgt/atxmega256a3bu/iar/: librf4ce-zrc-target.r90
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/config
    ../../../zrc/tgt/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/lib/unit_tests
    ../../: unit_tests.c unit_tests.h app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2102_rf4control/lib/unit_tests/xmega_a3bu_xplained_rz600rf212
    ../: conf_clock.h conf_board.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_test.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/lib/unit_tests/xmega_a3bu_xplained_rz600rf212/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../include/: nwk_build_config.h mac_user_build_config.h zid_device.h nwk_msg_code.h rf4ce.h gdp.h pb_pairing.h nwk_msg_types.h gdp_config.h nwk_config.h zid_build_config.h nwk_internal.h zrc.h zid_adaptor.h zid.h vendor_data.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../avr2025_mac/source/stb/src/: stb_armcrypto.c stb_help.c stb.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../avr2025_mac/source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../avr2025_mac/source/mac/src/: mac_process_tal_tx_frame_status.c mac_data_ind.c mac_rx_enable.c mac_process_beacon_frame.c mac_orphan.c mac_start.c mac_sync.c mac_associate.c mac.c mac_poll.c mac_tx_coord_realignment_command.c mac_beacon.c mac_dispatcher.c mac_data_extract_mhr.c mac_disassociate.c mac_scan.c mac_misc.c mac_mcps_data.c mac_data_req.c mac_gts.c mac_security.c mac_pib.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac_internal.h mac.h mac_msg_types.h mac_data_structures.h mac_security.h mac_msg_const.h mac_msg_type_data_ind.h mac_api.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/src
    ../../../../../avr2025_mac/source/tal/at86rf212/src/: tal.c tal_irq_handler.c tal_slotted_csma.c tal_pwr_mgmt.c tal_rx.c tal_pib.c tal_ed.c tal_init.c tal_rx_enable.c tal_tx.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/inc
    ../../../../../avr2025_mac/source/tal/at86rf212/inc/: tal_pib.h tal_tx.h at86rf212.h tal_config.h tal_internal.h tal_irq_handler.h tal_rx.h tal_slotted_csma.h tal_constants.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../avr2025_mac/source/tal/inc/: tal_helper.h tal_types.h tal_timer_config.h tal.h tal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../avr2025_mac/source/pal/: pal.c pal_ext_trx.c pal_generic.h pal_ext_trx.h pal.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/sal/atxmega_sal/src
    ../../../../../avr2025_mac/source/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../avr2025_mac/source/sal/inc/: sal_types.h sal_generic.h sal.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../avr2025_mac/include/: ieee_const.h mac_build_config.h return_val.h stack_config.h tal_build_config.h avr2025_mac.h
  group xmega/drivers/spi
    ../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usb
    ../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/tc
    ../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c led.h xmega_a3bu_xplained.h
  group xmega/utils
    ../../../../../../../xmega/utils/: assembler.h compiler.h status_codes.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../xmega/utils/preprocessor/: tpaste.h preprocessor.h mrepeat.h stringz.h
  group xmega/utils/bit_handling
    ../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../../xmega/utils/assembler/: iar.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/xmega
    ../../../../../../../common/services/clock/xmega/: sysclk.c osc.h sysclk.h pll.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../../common/services/usb/udc/: udc.c udd.h udc.h udi.h udc_desc.h
  group common/services/usb/class/cdc
    ../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport_compat.h ioport.h
  group common/services/gpio
    ../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/drivers/nvm
    ../../../../../../../common/drivers/nvm/: common_nvm.h
  group common/drivers/nvm/xmega
    ../../../../../../../common/drivers/nvm/xmega/: xmega_nvm.c
  group common/boards
    ../../../../../../../common/boards/: board.h
