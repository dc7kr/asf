# IAR project zrc_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: ZRC_CMD_DISCOVERY; UDD_ENABLE; SAL_TYPE=AT86RF2xx; NLDE_HANDLE; DISABLE_TSTAMP_IRQ=1; MAC_USER_BUILD_CONFIG; RF4CE_TARGET; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; TAL_TYPE=AT86RF212; TEST_SUITE_DEFINE_ASSERT_MACRO; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; BOARD=RZ600; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; RF4CE_CALLBACK_PARAM; _ASSERT_ENABLE_; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../common/services/usb/class/cdc/device; ../../../../../avr2025_mac/source/mac/inc; ../../../../../../../avr32/drivers/pm; ../../../../../../../avr32/boards; ../../../../../../../common/services/spi/uc3_spi; ../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../common/drivers/nvm; ../../../../../../../avr32/drivers/usbb; ../../../../include; ../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../services/trx_access; ../../../../../avr2025_mac/include; ../../../../../services/common_hw_timer/uc3; ../../../../../avr2025_mac/source/stb/inc; ../../../../../avr2025_mac/source/sal/inc; ../../../../../../../avr32/drivers/tc; ..; ../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../avr32/utils; ../../../../../../../avr32/drivers/gpio; ../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../common/utils; ../../../../../../../avr32/boards/rz600; ../../../../../../../avr32/drivers/spi; ../../../../../../../common/services/usb/class/cdc; ../../../../../../../common/services/clock; ../../../../../../../common/services/sleepmgr; ../../../../../../../common/services/usb; ../../../../../../../common/services/delay; ../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../services/common_hw_timer; ../../../../../avr2025_mac/source/tal/inc; ../../../../../avr2025_mac/source/pal; ../../../zrc/tgt/config; ../..; ../../../../../../../common/services/spi; ../../../../../../../common/boards; ../../../../../../../avr32/drivers/flashc; ../../../../../../../common/services/ioport; ../../../../../../../common/services/usb/udc; ../../../../../../../avr32/utils/preprocessor; ../../../../../avr2025_mac/source/tal/at86rf212/inc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/at32uc3a3256s/iar
    ../../../zrc/tgt/at32uc3a3256s/iar/: librf4ce-zrc-target.r82
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/tgt/config
    ../../../zrc/tgt/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/lib/unit_tests
    ../../: unit_tests.c unit_tests.h conf_trx_access.h app_config.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2102_rf4control/lib/unit_tests/at32uc3a3256s_rz600_at86rf212
    ../: conf_sleepmgr.h conf_clock.h conf_board.h conf_usb.h conf_spi_master.h conf_test.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/lib/unit_tests/at32uc3a3256s_rz600_at86rf212/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../include/: nwk_build_config.h mac_user_build_config.h zid_device.h nwk_msg_code.h rf4ce.h gdp.h pb_pairing.h nwk_msg_types.h gdp_config.h nwk_config.h zid_build_config.h nwk_internal.h zrc.h zid_adaptor.h zid.h vendor_data.h
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/uc3
    ../../../../../services/common_hw_timer/uc3/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/uc3/lib
    ../../../../../services/common_hw_timer/uc3/lib/: uc3_lib_hw_timer.r82
  group thirdparty/wireless/services/trx_access
    ../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../avr2025_mac/source/mac/src/: mac_orphan.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_process_beacon_frame.c mac_start.c mac_sync.c mac_associate.c mac.c mac_poll.c mac_tx_coord_realignment_command.c mac_data_ind.c mac_beacon.c mac_dispatcher.c mac_data_extract_mhr.c mac_disassociate.c mac_scan.c mac_misc.c mac_mcps_data.c mac_data_req.c mac_pib.c mac_gts.c mac_security.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac_internal.h mac.h mac_msg_types.h mac_data_structures.h mac_security.h mac_msg_const.h mac_msg_type_data_ind.h mac_api.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/src
    ../../../../../avr2025_mac/source/tal/at86rf212/src/: tal.c tal_irq_handler.c tal_rx_enable.c tal_slotted_csma.c tal_pwr_mgmt.c tal_rx.c tal_pib.c tal_ed.c tal_init.c tal_tx.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212/inc
    ../../../../../avr2025_mac/source/tal/at86rf212/inc/: tal_pib.h tal_tx.h at86rf212.h tal_config.h tal_internal.h tal_irq_handler.h tal_rx.h tal_slotted_csma.h tal_constants.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../avr2025_mac/source/tal/inc/: tal_helper.h tal_types.h tal.h tal_timer_config.h tal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../avr2025_mac/source/pal/: pal.c pal_ext_trx.c pal_generic.h pal_ext_trx.h pal.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../avr2025_mac/source/stb/src/: stb_armcrypto.c stb_help.c stb.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../avr2025_mac/source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/source/sal/at86rf2xx/src
    ../../../../../avr2025_mac/source/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../avr2025_mac/source/sal/inc/: sal_types.h sal_generic.h sal.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../avr2025_mac/include/: ieee_const.h mac_build_config.h return_val.h stack_config.h tal_build_config.h avr2025_mac.h
  group avr32/drivers/spi
    ../../../../../../../avr32/drivers/spi/: spi.c spi.h
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c flashc.h
  group avr32/drivers/pm
    ../../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c sleep.h power_clocks_lib.h pm.h
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c gpio.h
  group avr32/drivers/tc
    ../../../../../../../avr32/drivers/tc/: tc.c tc.h
  group avr32/drivers/usbb
    ../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_device.h usbb_otg.h
  group avr32/drivers/cpu/cycle_counter
    ../../../../../../../avr32/drivers/cpu/cycle_counter/: cycle_counter.h
  group avr32/boards/rz600
    ../../../../../../../avr32/boards/rz600/: init.c led.c rz600.h led.h
  group avr32/utils
    ../../../../../../../avr32/utils/: status_codes.h compiler.h
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82 trampoline_uc3.h
  group avr32/utils/header_files
    ../../../../../../../avr32/utils/header_files/: uc3l3_l4_defines_fix.h uc3d_defines_fix.h
  group avr32/utils/preprocessor
    ../../../../../../../avr32/utils/preprocessor/: preprocessor.h stringz.h tpaste.h mrepeat.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/unit_test
    ../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_avr32.h
  group common/services/usb
    ../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/udc
    ../../../../../../../common/services/usb/udc/: udc.c udd.h udc.h udi.h udc_desc.h
  group common/services/usb/class/cdc
    ../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc_conf.h udi_cdc.h
  group common/services/sleepmgr
    ../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/uc3
    ../../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c sleepmgr.h
  group common/services/spi
    ../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/uc3_spi
    ../../../../../../../common/services/spi/uc3_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../../../common/services/clock/: sysclk.h osc.h genclk.h pll.h
  group common/services/clock/uc3a3_a4
    ../../../../../../../common/services/clock/uc3a3_a4/: sysclk.c osc.h pll.h genclk.h sysclk.h
  group common/services/ioport
    ../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/uc3
    ../../../../../../../common/services/ioport/uc3/: ioport.h
  group common/services/delay
    ../../../../../../../common/services/delay/: delay.h
  group common/drivers/nvm
    ../../../../../../../common/drivers/nvm/: common_nvm.h
  group common/drivers/nvm/uc3
    ../../../../../../../common/drivers/nvm/uc3/: uc3_nvm.c flash_api.h
  group common/boards
    ../../../../../../../common/boards/: board.h
