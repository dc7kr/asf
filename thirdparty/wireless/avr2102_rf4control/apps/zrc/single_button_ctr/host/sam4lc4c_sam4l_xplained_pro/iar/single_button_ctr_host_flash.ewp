# IAR project single_button_ctr_host_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ENABLE_STACK_NVM; BOARD=SAM4L_XPLAINED_PRO; NLDE_HANDLE; __SAM4LC4C__; ZRC_CMD_DISCOVERY; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; ENABLE_PWR_SAVE_MODE; ARM_MATH_CM4=true; STB_ON_SAL; PBP_ORG; REDUCED_PARAM_CHECK; ZRC_PROFILE; CHANNEL_AGILITY; PRIVATE_NIB; RF4CE_PLATFORM; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCARM.CCIncludePath2: ../../../../../../../../../common/services/serial/sam_uart; ../../../../../../../../../common/boards; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../include; ../../..; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../avr2025_mac/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../addons/sio2host/uart; ..; ../../../../../../../../../common/services/serial; ../../../../../../addons/api_parser; ../..; ../../../../../../../addons/sio2ncp/uart; ../../../../../../../../../sam/drivers/wdt; ../../../../../../../../../common/services/clock; ../../../../../../../../../sam/boards; ../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../../../common/utils; ../../../../../../../avr2025_mac/source/pal; ../../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../../common/services/delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/tc; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../../common/services/ioport; ../../../../../../../../../sam/drivers/bpm; ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: single_button_ctr_host_flash.bin
  ILINK.IlinkOutputFile: single_button_ctr_host_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../avr2025_mac/include/: ieee_const.h stack_config.h mac_build_config.h tal_build_config.h return_val.h avr2025_mac.h
  group thirdparty/wireless/avr2102_rf4control/addons/api_parser
    ../../../../../../addons/api_parser/: api_parser.c api_parser.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr
    ../../../: main.c vendor_data.c
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr/host
    ../../: keyboard.h app_config.h conf_common_sw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr/host/sam4lc4c_sam4l_xplained_pro
    ../: conf_sio2host.h conf_uart_serial.h conf_clock.h conf_board.h conf_hw_timer.h conf_sio2ncp.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr/host/sam4lc4c_sam4l_xplained_pro/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../include/: nwk_msg_types.h mac_user_build_config.h nwk_msg_code.h rf4ce.h pb_pairing.h nwk_build_config.h zrc.h nwk_config.h vendor_data.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group thirdparty/wireless/addons/sio2ncp/uart
    ../../../../../../../addons/sio2ncp/uart/: sio2ncp.c sio2ncp.h
  group common/utils
    ../../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: genclk.h sysclk.h dfll.h pll.h osc.h
  group common/services/clock/sam4l
    ../../../../../../../../../common/services/clock/sam4l/: osc.c sysclk.c pll.c dfll.c sysclk.h dfll.h osc.h genclk.h pll.h
  group common/services/serial
    ../../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/tc
    ../../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/wdt
    ../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls2c.h sam4lc2b.h sam4ls2a.h sam4lc4b.h sam4l.h sam4lc4a.h sam4lc2c.h sam4lc2a.h sam4lc4c.h sam4lc8b.h sam4ls8b.h sam4ls4b.h sam4lc8a.h sam4lc8c.h sam4ls8c.h sam4ls2b.h sam4ls4a.h sam4ls4c.h sam4ls8a.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4ls4b.h pio_sam4lc8c.h pio_sam4lc2b.h pio_sam4ls8c.h pio_sam4lc2a.h pio_sam4ls2b.h pio_sam4ls8b.h pio_sam4ls4a.h pio_sam4lc4a.h pio_sam4lc4b.h pio_sam4ls2c.h pio_sam4lc2c.h pio_sam4ls4c.h pio_sam4ls8a.h pio_sam4ls2a.h pio_sam4lc4c.h pio_sam4lc8a.h pio_sam4lc8b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_gpio.h instance_spi.h instance_hflashc.h instance_twis1.h instance_usbc.h instance_bscif.h instance_hcache.h instance_parc.h instance_iisc.h instance_gloc.h instance_twis0.h instance_catb.h instance_crccu.h instance_adcife.h instance_twim1.h instance_twim2.h instance_bpm.h instance_twim3.h instance_trng.h instance_wdt.h instance_dacc.h instance_usart3.h instance_hmatrix.h instance_usart1.h instance_chipid.h instance_freqm.h instance_aesa.h instance_twim0.h instance_tc1.h instance_usart0.h instance_eic.h instance_abdacb.h instance_acifc.h instance_pm.h instance_pevc.h instance_scif.h instance_pdca.h instance_ast.h instance_usart2.h instance_lcdca.h instance_smap.h instance_picouart.h instance_tc0.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_tc.h component_gloc.h component_hcache.h component_adcife.h component_smap.h component_usbc.h component_gpio.h component_dacc.h component_wdt.h component_trng.h component_eic.h component_chipid.h component_usart.h component_lcdca.h component_iisc.h component_abdacb.h component_twis.h component_crccu.h component_twim.h component_acifc.h component_picouart.h component_freqm.h component_scif.h component_parc.h component_pevc.h component_hmatrixb.h component_ast.h component_flashcalw.h component_bscif.h component_catb.h component_pdca.h component_spi.h component_bpm.h component_pm.h component_aesa.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
