# IAR project single_button_ctr_ncp_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ZRC_CMD_DISCOVERY; BOARD=SAM4L_XPLAINED_PRO; SAL_TYPE=AT86RF2xx; NLDE_HANDLE; DISABLE_TSTAMP_IRQ=1; ENABLE_TFA; TFA_BAT_MON; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; ENABLE_STACK_NVM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; ENABLE_PWR_SAVE_MODE; ARM_MATH_CM4=true; PAL_USE_SPI_TRX=1; STB_ON_SAL; PBP_ORG; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; ZRC_PROFILE; PRIVATE_NIB; __SAM4LC4C__; RF4CE_CALLBACK_PARAM; TAL_TYPE=AT86RF233; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCARM.CCIncludePath2: ../../../../../../lib/zrc/ctr/config; ../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../../common/services/spi/sam_spi; ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm; ../../../../../../../../../common/boards; ../../../../../../../../../sam/utils/preprocessor; ..; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../include; ../../../../../../../avr2025_mac/source/resources/queue/inc; ../../..; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../avr2025_mac/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../addons/sio2host/uart; ../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../../common/services/serial; ../../../../../../../../../common/services/spi; ../../../../../../../avr2025_mac/source/tfa/inc; ../../../../../../../../../sam/drivers/spi; ../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../common/utils; ../../../../../../../avr2025_mac/source/tal/at86rf233/inc; ../../../../../../../../../sam/drivers/wdt; ../../../../../../../../../common/services/clock; ../../../../../../../../../sam/boards; ../../../../../../../../../common/utils/stdio/stdio_serial; ../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../avr2025_mac/source/pal; ../../../../../../../../../common/services/serial/sam_uart; ../../../../../../../avr2025_mac/source/pal/common_hw_timer; ../../../../../../../../../common/services/delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/tc; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../../common/services/ioport; ../../../../../../../../../sam/drivers/bpm; ../..; ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: single_button_ctr_ncp_flash.bin
  ILINK.IlinkOutputFile: single_button_ctr_ncp_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/ctr/atsam4lc4c/iar
    ../../../../../../lib/zrc/ctr/atsam4lc4c/iar/: librf4ce-zrc-controller.a
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr
    ../../../: vendor_data.c main.c
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal.c pal_ext_trx.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/: hw_timer.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_hw_timer/sam/lib
    ../../../../../../../avr2025_mac/source/pal/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm/sam
    ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm/sam/: sam_nvm.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../avr2025_mac/source/mac/src/: mac_disassociate.c mac_security.c mac_data_req.c mac_pib.c mac_tx_coord_realignment_command.c mac_misc.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_poll.c mac_rx_enable.c mac_mcps_data.c mac_data_extract_mhr.c mac_data_ind.c mac_scan.c mac.c mac_dispatcher.c mac_orphan.c mac_start.c mac_associate.c mac_sync.c mac_beacon.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../../../avr2025_mac/source/tal/at86rf233/src/: tal.c tal_irq_handler.c tal_init.c tal_slotted_csma.c tal_rx_enable.c tal_pwr_mgmt.c tal_tx.c tal_rx.c tal_ed.c tal_pib.c
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../avr2025_mac/source/stb/src/: stb_help.c stb.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/sal/at86rf2xx/src
    ../../../../../../../avr2025_mac/source/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf233/src
    ../../../../../../../avr2025_mac/source/tfa/at86rf233/src/: tfa.c
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../addons/sio2host/uart/: sio2host.c
  group common/utils/stdio
    ../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/delay/sam
    ../../../../../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/serial
    ../../../../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/sam4l
    ../../../../../../../../../common/services/clock/sam4l/: pll.c osc.c sysclk.c dfll.c
  group common/services/spi/sam_spi
    ../../../../../../../../../common/services/spi/sam_spi/: spi_master.c
  group sam/drivers/spi
    ../../../../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/wdt
    ../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/drivers/tc
    ../../../../../../../../../sam/drivers/tc/: tc.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c
