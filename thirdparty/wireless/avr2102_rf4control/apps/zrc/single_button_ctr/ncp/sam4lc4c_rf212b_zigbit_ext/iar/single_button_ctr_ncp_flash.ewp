# IAR project single_button_ctr_ncp_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ZRC_CMD_DISCOVERY; BOARD=SAM4L_XPLAINED_PRO; SAL_TYPE=AT86RF2xx; NLDE_HANDLE; DISABLE_TSTAMP_IRQ=1; ENABLE_TFA; TFA_BAT_MON; VENDOR_DATA; MAC_USER_BUILD_CONFIG; ENABLE_TRX_SRAM; ENABLE_STACK_NVM; RF4CE_SECURITY; TAL_TYPE=AT86RF212B; RSSI_TO_LQI_MAPPING; ENABLE_PWR_SAVE_MODE; ARM_MATH_CM4=true; PAL_USE_SPI_TRX=1; STB_ON_SAL; PBP_ORG; REDUCED_PARAM_CHECK; ZRC_PROFILE; PRIVATE_NIB; __SAM4LC4C__; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; SIO_HUB
  ICCARM.CCIncludePath2: ../../../../../../lib/zrc/ctr/config; ../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../../common/services/spi/sam_spi; ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm; ../../../../../../../../../common/boards; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../include; ../../../../../../../avr2025_mac/source/resources/queue/inc; ../../..; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../services/trx_access; ../../../../../../../avr2025_mac/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../addons/sio2host/uart; ../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../../common/services/serial; ../../../../../../../avr2025_mac/source/tfa/inc; ../../../../../../../../../sam/drivers/spi; ../../../../../../../../../sam/boards; ../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../common/utils; ../../../../../../../../../sam/drivers/wdt; ../../../../../../../../../common/services/clock; ../../../../../../../services/common_hw_timer/sam; ../../../../../../../../../common/utils/stdio/stdio_serial; ..; ../../../../../../../services/common_hw_timer; ../../../../../../../avr2025_mac/source/tal/at86rf212b/inc; ../../../../../../../avr2025_mac/source/pal; ../../../../../../../../../common/services/serial/sam_uart; ../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../../../common/services/delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/tc; ../../../../../../../../../common/services/spi; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../sam/boards/sam4l_xplained_pro; ../../../../../../../../../common/services/ioport; ../../../../../../../../../sam/drivers/bpm; ../..; ../../../../../../../../../sam/drivers/usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: single_button_ctr_ncp_flash.bin
  ILINK.IlinkOutputFile: single_button_ctr_ncp_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/ctr/atsam4lc4c/iar
    ../../../../../../lib/zrc/ctr/atsam4lc4c/iar/: librf4ce-zrc-controller.a
  group thirdparty/wireless/avr2102_rf4control/lib/zrc/ctr/config
    ../../../../../../lib/zrc/ctr/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr
    ../../../: main.c vendor_data.c
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr/ncp
    ../../: keyboard.h app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr/ncp/sam4lc4c_rf212b_zigbit_ext
    ../: conf_sio2host.h conf_uart_serial.h conf_board.h conf_spi_master.h conf_clock.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zrc/single_button_ctr/ncp/sam4lc4c_rf212b_zigbit_ext/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../include/: nwk_msg_types.h mac_user_build_config.h zid_build_config.h nwk_internal.h gdp_config.h zid_adaptor.h nwk_msg_code.h rf4ce.h pb_pairing.h nwk_build_config.h gdp.h zid.h zrc.h nwk_config.h vendor_data.h zid_device.h
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam
    ../../../../../../../services/common_hw_timer/sam/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/sam/lib
    ../../../../../../../services/common_hw_timer/sam/lib/: sam4l_lib_hw_timer.a
  group thirdparty/wireless/services/trx_access
    ../../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal.c pal_ext_trx.c pal_generic.h pal.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm
    ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm/: common_nvm.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm/sam
    ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm/sam/: sam_nvm.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/src
    ../../../../../../../avr2025_mac/source/tal/at86rf212b/src/: tal_irq_handler.c tal_rx_enable.c tal_tx.c tal_pwr_mgmt.c tal_slotted_csma.c tal.c tal_init.c tal_rx.c tal_pib.c tal_ed.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/inc
    ../../../../../../../avr2025_mac/source/tal/at86rf212b/inc/: tal_constants.h tal_irq_handler.h tal_tx.h tal_internal.h tal_rx.h tal_config.h at86rf212b.h tal_slotted_csma.h tal_pib.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../avr2025_mac/source/tal/inc/: tal_types.h tal.h tal_generic.h tal_helper.h tal_timer_config.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../avr2025_mac/source/mac/src/: mac_security.c mac_data_req.c mac_disassociate.c mac_pib.c mac_misc.c mac_gts.c mac_process_beacon_frame.c mac_process_tal_tx_frame_status.c mac_poll.c mac_rx_enable.c mac_mcps_data.c mac_data_extract_mhr.c mac_data_ind.c mac_scan.c mac_tx_coord_realignment_command.c mac.c mac_dispatcher.c mac_orphan.c mac_start.c mac_associate.c mac_sync.c mac_beacon.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac_msg_types.h mac_msg_const.h mac_msg_type_data_ind.h mac.h mac_internal.h mac_data_structures.h mac_security.h mac_api.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../avr2025_mac/source/stb/src/: stb_help.c stb.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../avr2025_mac/source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/source/tfa/at86rf212b/src
    ../../../../../../../avr2025_mac/source/tfa/at86rf212b/src/: tfa.c
  group thirdparty/wireless/avr2025_mac/source/tfa/inc
    ../../../../../../../avr2025_mac/source/tfa/inc/: tfa.h
  group thirdparty/wireless/avr2025_mac/source/sal/at86rf2xx/src
    ../../../../../../../avr2025_mac/source/sal/at86rf2xx/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../avr2025_mac/source/sal/inc/: sal.h sal_types.h sal_generic.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../avr2025_mac/include/: ieee_const.h stack_config.h mac_build_config.h tal_build_config.h return_val.h avr2025_mac.h
  group thirdparty/wireless/addons/sio2host/uart
    ../../../../../../../addons/sio2host/uart/: sio2host.c sio2host.h
  group sam/drivers/spi
    ../../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/tc
    ../../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4lc8a.h sam4ls2c.h sam4lc2b.h sam4ls2a.h sam4lc4b.h sam4l.h sam4ls8c.h sam4lc4a.h sam4lc2c.h sam4lc2a.h sam4lc4c.h sam4lc8b.h sam4ls8b.h sam4ls4a.h sam4ls4b.h sam4lc8c.h sam4ls2b.h sam4ls4c.h sam4ls8a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_gpio.h instance_spi.h instance_pevc.h instance_twis1.h instance_usbc.h instance_twis0.h instance_hflashc.h instance_hcache.h instance_parc.h instance_iisc.h instance_gloc.h instance_catb.h instance_crccu.h instance_adcife.h instance_twim1.h instance_twim2.h instance_bpm.h instance_twim3.h instance_trng.h instance_wdt.h instance_bscif.h instance_dacc.h instance_usart3.h instance_hmatrix.h instance_usart1.h instance_chipid.h instance_freqm.h instance_aesa.h instance_twim0.h instance_tc1.h instance_usart0.h instance_eic.h instance_abdacb.h instance_acifc.h instance_scif.h instance_pdca.h instance_ast.h instance_pm.h instance_usart2.h instance_lcdca.h instance_smap.h instance_picouart.h instance_tc0.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_gloc.h component_hcache.h component_adcife.h component_smap.h component_usbc.h component_freqm.h component_gpio.h component_dacc.h component_wdt.h component_trng.h component_eic.h component_bpm.h component_usart.h component_lcdca.h component_iisc.h component_abdacb.h component_twis.h component_twim.h component_picouart.h component_scif.h component_parc.h component_pevc.h component_hmatrixb.h component_tc.h component_ast.h component_flashcalw.h component_bscif.h component_chipid.h component_catb.h component_pdca.h component_spi.h component_crccu.h component_acifc.h component_pm.h component_aesa.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc8c.h pio_sam4lc2b.h pio_sam4ls8c.h pio_sam4lc2a.h pio_sam4ls2b.h pio_sam4ls8b.h pio_sam4ls4a.h pio_sam4ls4b.h pio_sam4lc4b.h pio_sam4ls2c.h pio_sam4lc2c.h pio_sam4ls4c.h pio_sam4ls8a.h pio_sam4ls2a.h pio_sam4lc4c.h pio_sam4lc8a.h pio_sam4lc8b.h pio_sam4lc4a.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_xplained_pro
    ../../../../../../../../../sam/boards/sam4l_xplained_pro/: init.c sam4l_xplained_pro.h led.h
  group common/services/delay
    ../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/serial
    ../../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: pll.h genclk.h osc.h sysclk.h dfll.h
  group common/services/clock/sam4l
    ../../../../../../../../../common/services/clock/sam4l/: pll.c osc.c sysclk.c dfll.c sysclk.h dfll.h osc.h genclk.h pll.h
  group common/services/spi
    ../../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/ioport
    ../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../../common/services/ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
