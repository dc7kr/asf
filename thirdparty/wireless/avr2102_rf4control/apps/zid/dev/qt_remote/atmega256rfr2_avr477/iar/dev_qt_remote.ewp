# IAR project dev_qt_remote.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: SAL_TYPE=ATMEGARF_SAL; STB_ON_SAL; ZID_DEVICE; PBP_ORG; RF4CE_CALLBACK_PARAM; VENDOR_DATA; MAC_USER_BUILD_CONFIG; HIGHEST_STACK_LAYER=RF4CE; ENABLE_STACK_NVM; EXTERN_EEPROM_AVAILABLE=0; REDUCED_PARAM_CHECK; AVR477_QTOUCH; NLDE_HANDLE; ZID_PROFILE; RF4CE_SECURITY; TAL_USER_BUILD_CONFIG; GDP_PROFILE; RSSI_TO_LQI_MAPPING; BOARD=DUMMY_BOARD; TAL_TYPE=ATMEGARFR2; PRIVATE_NIB
  ICCAVR.newCCIncludePaths: ../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../../mega/utils/preprocessor; ../../../../../../../../../mega/utils; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../include; ../../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../../../mega/boards/dummy; ../../../../../../../avr2025_mac/include; ../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../avr2025_mac/source/sal/inc; ../..; ../../../../../../../services/mega/drivers/flash; ../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../common/utils; ../../../../../../../avr2025_mac/source/tal/atmegarfr2/inc; ../../avr_477/board; ../../../../../../../../../mega/drivers/cpu; ../../../../../../../../../common/services/clock; ../../../../../../../../../mega/boards; ../../../../../../../services/common_hw_timer/mega; ../../../../../../../services/common_hw_timer; ../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../avr2025_mac/source/pal; ../../../../../../../../../common/services/gpio; ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm; ../../../../../../../../../common/services/delay; ../../avr_477/inc; ../../../../../../lib/zid/dev/config; ../../../../../../../../../common/boards; ..; ../../avr_477; ../../../../../../../../../common/services/ioport; ../../../../../../../services/mega/drivers/tc; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
  XLINK.XclFile: ../link_iar.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; SAL_TYPE=ATMEGARF_SAL; STB_ON_SAL; ZID_DEVICE; PBP_ORG; RF4CE_CALLBACK_PARAM; VENDOR_DATA; MAC_USER_BUILD_CONFIG; HIGHEST_STACK_LAYER=RF4CE; ENABLE_STACK_NVM; EXTERN_EEPROM_AVAILABLE=0; REDUCED_PARAM_CHECK; AVR477_QTOUCH; NLDE_HANDLE; ZID_PROFILE; RF4CE_SECURITY; TAL_USER_BUILD_CONFIG; GDP_PROFILE; RSSI_TO_LQI_MAPPING; BOARD=DUMMY_BOARD; TAL_TYPE=ATMEGARFR2; PRIVATE_NIB
  group thirdparty/wireless/avr2102_rf4control/lib/zid/dev/atmega256rfr2/iar
    ../../../../../../lib/zid/dev/atmega256rfr2/iar/: librf4ce-zid-device.r90
  group thirdparty/wireless/avr2102_rf4control/lib/zid/dev/config
    ../../../../../../lib/zid/dev/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/apps/zid/dev/qt_remote
    ../../: vendor_data.c main.c app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2102_rf4control/apps/zid/dev/qt_remote/avr_477/lib/iar
    ../../avr_477/lib/iar/: libm256rfr2_32qm_8x_4y_krs_4rs.r90
  group thirdparty/wireless/avr2102_rf4control/apps/zid/dev/qt_remote/avr_477/src
    ../../avr_477/src/: avr477QTouch.c memorymap.c qm_asm_tiny_mega.S
  group thirdparty/wireless/avr2102_rf4control/apps/zid/dev/qt_remote/avr_477/board
    ../../avr_477/board/: init.c led.h avr477.h
  group thirdparty/wireless/avr2102_rf4control/apps/zid/dev/qt_remote/avr_477/inc
    ../../avr_477/inc/: touch_config.h Avr477QTouch.h qm_asm_avr.h buttonsExt.h memorymap.h touch_api.h
  group thirdparty/wireless/avr2102_rf4control/apps/zid/dev/qt_remote/atmega256rfr2_avr477
    ../: conf_flash.h conf_clock.h conf_board.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zid/dev/qt_remote/atmega256rfr2_avr477/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../include/: nwk_msg_types.h mac_user_build_config.h zid_build_config.h nwk_internal.h gdp_config.h zid_adaptor.h rf4ce.h pb_pairing.h nwk_build_config.h gdp.h zid.h zrc.h nwk_config.h vendor_data.h nwk_msg_code.h zid_device.h
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega
    ../../../../../../../services/common_hw_timer/mega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/mega/lib
    ../../../../../../../services/common_hw_timer/mega/lib/: megarfr2_lib_hw_timer.r90
  group thirdparty/wireless/services/mega/drivers/tc
    ../../../../../../../services/mega/drivers/tc/: tc_megarf.c tc_megarf.h
  group thirdparty/wireless/services/mega/drivers/flash
    ../../../../../../../services/mega/drivers/flash/: flash.c flash.h
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/src
    ../../../../../../../avr2025_mac/source/tal/atmegarfr2/src/: tal_irq_handler.c tal_init.c tal_rx.c tal_rx_enable.c tal.c tal_pib.c tal_pwr_mgmt.c tal_ed.c tal_slotted_csma.c tal_tx.c
  group thirdparty/wireless/avr2025_mac/source/tal/atmegarfr2/inc
    ../../../../../../../avr2025_mac/source/tal/atmegarfr2/inc/: tal_rx.h atmega256rfr2.h tal_internal.h tal_tx.h tal_pib.h tal_irq_handler.h tal_config.h tal_constants.h tal_slotted_csma.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../avr2025_mac/source/tal/inc/: tal_types.h tal.h tal_generic.h tal_helper.h tal_timer_config.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../avr2025_mac/source/mac/src/: mac_security.c mac_poll.c mac_beacon.c mac_data_req.c mac_disassociate.c mac_pib.c mac_misc.c mac_gts.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_mcps_data.c mac_process_beacon_frame.c mac_data_extract_mhr.c mac_data_ind.c mac_scan.c mac_associate.c mac.c mac_dispatcher.c mac_orphan.c mac_start.c mac_tx_coord_realignment_command.c mac_sync.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac_msg_types.h mac_msg_const.h mac_internal.h mac_msg_type_data_ind.h mac.h mac_security.h mac_data_structures.h mac_api.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal.c pal.h pal_generic.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm
    ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm/: common_nvm.h
  group thirdparty/wireless/avr2025_mac/source/pal/common/drivers/nvm/mega
    ../../../../../../../avr2025_mac/source/pal/common/drivers/nvm/mega/: mega_nvm.c
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/sal/atmegarf_sal/src
    ../../../../../../../avr2025_mac/source/sal/atmegarf_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../avr2025_mac/source/sal/inc/: sal_types.h sal_generic.h sal.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../avr2025_mac/source/stb/src/: stb.c stb_help.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../avr2025_mac/source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../avr2025_mac/include/: ieee_const.h mac_build_config.h tal_build_config.h avr2025_mac.h return_val.h stack_config.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: sysclk.h
  group common/services/clock/mega
    ../../../../../../../../../common/services/clock/mega/: sysclk.c sysclk.h
  group common/services/gpio
    ../../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/mega_gpio
    ../../../../../../../../../common/services/gpio/mega_gpio/: mega_gpio.h
  group common/services/delay
    ../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/mega
    ../../../../../../../../../common/services/delay/mega/: cycle_counter.h
  group common/services/ioport
    ../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/mega
    ../../../../../../../../../common/services/ioport/mega/: ioport.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
  group mega/utils
    ../../../../../../../../../mega/utils/: assembler.h status_codes.h progmem.h compiler.h
  group mega/utils/preprocessor
    ../../../../../../../../../mega/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group mega/utils/assembler
    ../../../../../../../../../mega/utils/assembler/: iar.h
  group mega/boards/dummy
    ../../../../../../../../../mega/boards/dummy/: dummy_board.h
  group mega/drivers/cpu
    ../../../../../../../../../mega/drivers/cpu/: mega_reset_cause.h
