# IAR project adptr_usb_hid.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x400
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: MAC_USER_BUILD_CONFIG; FLASH_SUPPORT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; TAL_USER_BUILD_CONFIG; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; RF4CE_TARGET; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; ZID_ADAPTOR; BOARD=XMEGA_RF233_ZIGBIT; CHANNEL_AGILITY; PRIVATE_NIB; ZID_PROFILE; RF4CE_CALLBACK_PARAM; TAL_TYPE=AT86RF233; HIGHEST_STACK_LAYER=RF4CE; GDP_PROFILE; SIO_HUB
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../avr2025_mac/source/mac/inc; ../../../../../../../../../xmega/drivers/pmic; ../../../../../../../../../common/services/spi/xmega_spi; ../../../../../../../../../xmega/drivers/tc; ../../../../../../../../../xmega/utils; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../../../common/drivers/nvm; ../../../../../../include; ../../../../../../../avr2025_mac/source/resources/queue/inc; ../..; ../../../../../../../services/trx_access; ../../../../../../../avr2025_mac/include; ../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../avr2025_mac/source/stb/inc; ..; ../../../../../../../../../common/services/gpio; ../../../../../../../../../common/services/ioport; ../../../../../../lib/zid/aptr/config; ../../../../../../../../../xmega/boards/xmega_rf233_zigbit; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../common/utils; ../../../../../../../avr2025_mac/source/tal/at86rf233/inc; ../../../../../../../../../common/services/usb/class/composite/device; ../../../../../../../../../common/services/usb/class/hid/device/mouse; ../../../../../../../../../common/services/clock; ../../../../../../../../../common/services/usb/udc; ../../../../../../../../../common/services/usb; ../../../../../../../services/common_hw_timer; ../../../../../../../../../xmega/boards; ../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../avr2025_mac/source/pal; ../../../../../../../services/common_hw_timer/xmega; ../../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../../common/services/delay; ../../../../../../../../../common/services/usb/class/hid/device; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../../../common/services/spi; ../../../../../../../../../common/boards; ../../../../../../addons/kbd; ../../../../../../../../../xmega/drivers/spi; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../common/services/usb/class/hid; ../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; MAC_USER_BUILD_CONFIG; FLASH_SUPPORT; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; TAL_USER_BUILD_CONFIG; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; RF4CE_TARGET; DEBUG=0; VENDOR_DATA; ENABLE_STACK_NVM; RF4CE_SECURITY; RSSI_TO_LQI_MAPPING; PBP_REC; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; EXTERN_EEPROM_AVAILABLE=0; ZID_ADAPTOR; BOARD=XMEGA_RF233_ZIGBIT; CHANNEL_AGILITY; PRIVATE_NIB; ZID_PROFILE; RF4CE_CALLBACK_PARAM; TAL_TYPE=AT86RF233; HIGHEST_STACK_LAYER=RF4CE; GDP_PROFILE; SIO_HUB
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega
    ../../../../../../../services/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega/lib
    ../../../../../../../services/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/services/trx_access
    ../../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2102_rf4control/lib/zid/aptr/atxmega256a3u/iar
    ../../../../../../lib/zid/aptr/atxmega256a3u/iar/: librf4ce-zid-adaptor.r90
  group thirdparty/wireless/avr2102_rf4control/lib/zid/aptr/config
    ../../../../../../lib/zid/aptr/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/addons/kbd
    ../../../../../../addons/kbd/: udi_hid_kbd.c udi_hid_kbd.h
  group thirdparty/wireless/avr2102_rf4control/apps/zid/adptr/usb_hid
    ../../: vendor_data.c main.c app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2102_rf4control/apps/zid/adptr/usb_hid/atxmega256a3u_rf233_zigbit_usb
    ../: conf_board.h conf_clock.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/zid/adptr/usb_hid/atxmega256a3u_rf233_zigbit_usb/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../include/: mac_user_build_config.h zid_build_config.h nwk_msg_types.h gdp_config.h zid_adaptor.h nwk_internal.h gdp.h rf4ce.h pb_pairing.h nwk_build_config.h zid.h zrc.h nwk_config.h vendor_data.h nwk_msg_code.h zid_device.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../avr2025_mac/source/mac/src/: mac_security.c mac_beacon.c mac_data_req.c mac_disassociate.c mac_pib.c mac_tx_coord_realignment_command.c mac_misc.c mac_gts.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_mcps_data.c mac_process_beacon_frame.c mac_data_extract_mhr.c mac_data_ind.c mac_scan.c mac.c mac_dispatcher.c mac_orphan.c mac_poll.c mac_start.c mac_associate.c mac_sync.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac.h mac_msg_const.h mac_internal.h mac_msg_types.h mac_msg_type_data_ind.h mac_api.h mac_security.h mac_data_structures.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/src
    ../../../../../../../avr2025_mac/source/tal/at86rf233/src/: tal.c tal_irq_handler.c tal_init.c tal_slotted_csma.c tal_rx_enable.c tal_pwr_mgmt.c tal_rx.c tal_tx.c tal_ed.c tal_pib.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf233/inc
    ../../../../../../../avr2025_mac/source/tal/at86rf233/inc/: tal_slotted_csma.h tal_irq_handler.h tal_constants.h at86rf233.h tal_tx.h tal_rx.h tal_config.h tal_internal.h tal_pib.h
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../avr2025_mac/source/tal/inc/: tal_types.h tal.h tal_generic.h tal_helper.h tal_timer_config.h
  group thirdparty/wireless/avr2025_mac/source/sal/atxmega_sal/src
    ../../../../../../../avr2025_mac/source/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../avr2025_mac/source/sal/inc/: sal_types.h sal_generic.h sal.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../avr2025_mac/source/stb/src/: stb.c stb_help.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../avr2025_mac/source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal.c pal_ext_trx.c pal.h pal_generic.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../avr2025_mac/include/: ieee_const.h mac_build_config.h tal_build_config.h avr2025_mac.h return_val.h stack_config.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: pll.h genclk.h sysclk.h osc.h
  group common/services/clock/xmega
    ../../../../../../../../../common/services/clock/xmega/: sysclk.c osc.h sysclk.h pll.h
  group common/services/spi
    ../../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/usb
    ../../../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/composite/device
    ../../../../../../../../../common/services/usb/class/composite/device/: udi_composite_desc.c udi_composite_conf.h
  group common/services/usb/class/hid
    ../../../../../../../../../common/services/usb/class/hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../../../../../common/services/usb/class/hid/device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../../../../../common/services/usb/class/hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse.h
  group common/services/usb/udc
    ../../../../../../../../../common/services/usb/udc/: udc.c udc_desc.h udc.h udd.h udi.h
  group common/services/sleepmgr
    ../../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/gpio
    ../../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/drivers/nvm
    ../../../../../../../../../common/drivers/nvm/: common_nvm.h
  group common/drivers/nvm/xmega
    ../../../../../../../../../common/drivers/nvm/xmega/: xmega_nvm.c
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/boards
    ../../../../../../../../../common/boards/: board.h
  group xmega/drivers/spi
    ../../../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/tc
    ../../../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_rf233_zigbit
    ../../../../../../../../../xmega/boards/xmega_rf233_zigbit/: init.c xmega_rf233_zigbit.h led.h
  group xmega/utils
    ../../../../../../../../../xmega/utils/: assembler.h status_codes.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../../../xmega/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group xmega/utils/bit_handling
    ../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../../../../xmega/utils/assembler/: iar.h
