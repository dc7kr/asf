# IAR project serial_if_ncp.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x200
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: MAC_USER_BUILD_CONFIG; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; _DEBUG_=0; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; RF4CE_SECURITY; TAL_TYPE=AT86RF212B; RSSI_TO_LQI_MAPPING; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; BOARD=XMEGA_RF212B_ZIGBIT; CHANNEL_AGILITY; PRIVATE_NIB; SIO_HUB; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; RF4CE_PLATFORM
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../common/services/usb/class/cdc/device; ../../../../../../../avr2025_mac/source/mac/inc; ..; ../../../../../../../../../common/services/spi/xmega_spi; ../../../../../../addons/serial_interface; ../../../../../../../../../xmega/drivers/tc; ../../../../../../../../../xmega/utils; ../../../../../../../avr2025_mac/source/pal/common_sw_timer; ../../../../../../../../../common/drivers/nvm; ../../../../../../include; ../../../../../../../avr2025_mac/source/resources/queue/inc; ../../../../../../../avr2025_mac/source/tal/inc; ../../../../../../../services/trx_access; ../../../../../../../avr2025_mac/include; ../../../../../../../avr2025_mac/source/stb/inc; ../../../../../../../../../xmega/drivers/pmic; ../../../../../../../../../common/services/gpio; ../../../../../../../../../common/services/ioport; ../../../../../../../addons/sio2host/usb; ../../../../../../../../../common/utils/stdio/stdio_usb; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../../../common/services/sleepmgr; ../../../../../../../../../common/utils; ../../../../../../../../../common/services/usb/class/cdc; ../..; ../../../../../../../../../common/services/clock; ../../../../../../../avr2025_mac/source/resources/buffer/inc; ../../../../../../../../../common/services/usb; ../../../../../../../services/common_hw_timer; ../../../../../../../../../xmega/boards; ../../../../../../../../../xmega/boards/xmega_rf212b_zigbit; ../../../../../../../avr2025_mac/source/tal/at86rf212b/inc; ../../../../../../../avr2025_mac/source/pal; ../../../../../../../services/common_hw_timer/xmega; ../../../../../../lib/nwk/config; ../../../../../../../avr2025_mac/source/sal/inc; ../../../../../../../../../common/services/delay; ../../../../../../../../../common/services/usb/udc; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../../../common/services/spi; ../../../../../../../../../common/boards; ../../../../../../../../../xmega/drivers/spi; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; MAC_USER_BUILD_CONFIG; IOPORT_XMEGA_COMPAT; NLDE_HANDLE; SAL_TYPE=ATXMEGA_SAL; DISABLE_TSTAMP_IRQ=1; _DEBUG_=0; ENABLE_STACK_NVM; ENABLE_TRX_SRAM; RF4CE_SECURITY; TAL_TYPE=AT86RF212B; RSSI_TO_LQI_MAPPING; PAL_USE_SPI_TRX=1; STB_ON_SAL; REDUCED_PARAM_CHECK; BOARD=XMEGA_RF212B_ZIGBIT; CHANNEL_AGILITY; PRIVATE_NIB; SIO_HUB; RF4CE_CALLBACK_PARAM; HIGHEST_STACK_LAYER=RF4CE; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; RF4CE_PLATFORM
  group thirdparty/wireless/services/common_hw_timer
    ../../../../../../../services/common_hw_timer/: common_hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega
    ../../../../../../../services/common_hw_timer/xmega/: hw_timer.c hw_timer.h
  group thirdparty/wireless/services/common_hw_timer/xmega/lib
    ../../../../../../../services/common_hw_timer/xmega/lib/: xmegaa3_lib_hw_timer.r90
  group thirdparty/wireless/services/trx_access
    ../../../../../../../services/trx_access/: trx_access.c trx_access.h
  group thirdparty/wireless/avr2102_rf4control/lib/nwk/atxmega256a3u/iar
    ../../../../../../lib/nwk/atxmega256a3u/iar/: librf4ce-nwk.r90
  group thirdparty/wireless/avr2102_rf4control/lib/nwk/config
    ../../../../../../lib/nwk/config/: node_config.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if
    ../../../: main.c
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp
    ../../: app_config.h conf_common_sw_timer.h conf_trx_access.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp/atxmega256a3u_rf212b_zigbit_usb
    ../: conf_sio2host.h conf_board.h conf_clock.h conf_usb.h conf_spi_master.h conf_sleepmgr.h conf_nvm.h conf_hw_timer.h
  group thirdparty/wireless/avr2102_rf4control/apps/nwk/serial_if/ncp/atxmega256a3u_rf212b_zigbit_usb/iar
    ./: asf.h
  group thirdparty/wireless/avr2102_rf4control/addons/serial_interface
    ../../../../../../addons/serial_interface/: serial_interface.c serial_interface.h
  group thirdparty/wireless/avr2102_rf4control/include
    ../../../../../../include/: nwk_msg_types.h mac_user_build_config.h zid_build_config.h gdp_config.h zid_adaptor.h nwk_internal.h rf4ce.h pb_pairing.h nwk_build_config.h gdp.h zid.h zrc.h nwk_config.h vendor_data.h nwk_msg_code.h zid_device.h
  group thirdparty/wireless/avr2025_mac/source/mac/src
    ../../../../../../../avr2025_mac/source/mac/src/: mac_security.c mac_data_req.c mac_disassociate.c mac_pib.c mac_misc.c mac_gts.c mac_process_tal_tx_frame_status.c mac_rx_enable.c mac_mcps_data.c mac_process_beacon_frame.c mac_data_extract_mhr.c mac_data_ind.c mac_scan.c mac_tx_coord_realignment_command.c mac.c mac_dispatcher.c mac_orphan.c mac_poll.c mac_start.c mac_associate.c mac_sync.c mac_beacon.c
  group thirdparty/wireless/avr2025_mac/source/mac/inc
    ../../../../../../../avr2025_mac/source/mac/inc/: mac_config.h mac.h mac_msg_const.h mac_internal.h mac_msg_types.h mac_msg_type_data_ind.h mac_api.h mac_security.h mac_data_structures.h
  group thirdparty/wireless/avr2025_mac/source/tal/src
    ../../../../../../../avr2025_mac/source/tal/src/: tal_helper.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/src
    ../../../../../../../avr2025_mac/source/tal/at86rf212b/src/: tal_tx.c tal_pwr_mgmt.c tal_slotted_csma.c tal_irq_handler.c tal.c tal_rx.c tal_init.c tal_pib.c tal_ed.c tal_rx_enable.c
  group thirdparty/wireless/avr2025_mac/source/tal/at86rf212b/inc
    ../../../../../../../avr2025_mac/source/tal/at86rf212b/inc/: tal_constants.h tal_tx.h tal_irq_handler.h tal_internal.h tal_rx.h tal_config.h at86rf212b.h tal_slotted_csma.h tal_pib.h
  group thirdparty/wireless/avr2025_mac/source/tal/inc
    ../../../../../../../avr2025_mac/source/tal/inc/: tal_types.h tal.h tal_helper.h tal_timer_config.h tal_generic.h
  group thirdparty/wireless/avr2025_mac/source/sal/atxmega_sal/src
    ../../../../../../../avr2025_mac/source/sal/atxmega_sal/src/: sal.c
  group thirdparty/wireless/avr2025_mac/source/sal/inc
    ../../../../../../../avr2025_mac/source/sal/inc/: sal_types.h sal_generic.h sal.h
  group thirdparty/wireless/avr2025_mac/source/pal
    ../../../../../../../avr2025_mac/source/pal/: pal_ext_trx.c pal.c pal.h pal_generic.h pal_ext_trx.h
  group thirdparty/wireless/avr2025_mac/source/pal/common_sw_timer
    ../../../../../../../avr2025_mac/source/pal/common_sw_timer/: common_sw_timer.c common_sw_timer.h
  group thirdparty/wireless/avr2025_mac/source/stb/src
    ../../../../../../../avr2025_mac/source/stb/src/: stb.c stb_help.c stb_armcrypto.c
  group thirdparty/wireless/avr2025_mac/source/stb/inc
    ../../../../../../../avr2025_mac/source/stb/inc/: stb_internal.h stb_generic.h stb_armcrypto.h stb.h
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/src
    ../../../../../../../avr2025_mac/source/resources/buffer/src/: bmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/buffer/inc
    ../../../../../../../avr2025_mac/source/resources/buffer/inc/: bmm.h
  group thirdparty/wireless/avr2025_mac/source/resources/queue/src
    ../../../../../../../avr2025_mac/source/resources/queue/src/: qmm.c
  group thirdparty/wireless/avr2025_mac/source/resources/queue/inc
    ../../../../../../../avr2025_mac/source/resources/queue/inc/: qmm.h
  group thirdparty/wireless/avr2025_mac/include
    ../../../../../../../avr2025_mac/include/: ieee_const.h mac_build_config.h tal_build_config.h avr2025_mac.h return_val.h stack_config.h
  group thirdparty/wireless/addons/sio2host/usb
    ../../../../../../../addons/sio2host/usb/: sio2host.c sio2host.h
  group common/utils
    ../../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../../../../../common/utils/stdio/stdio_usb/: stdio_usb.c stdio_usb.h
  group common/utils/interrupt
    ../../../../../../../../../common/utils/interrupt/: interrupt_avr8.h
  group common/services/clock
    ../../../../../../../../../common/services/clock/: pll.h genclk.h sysclk.h osc.h
  group common/services/clock/xmega
    ../../../../../../../../../common/services/clock/xmega/: sysclk.c osc.h sysclk.h pll.h
  group common/services/spi
    ../../../../../../../../../common/services/spi/: spi_master.h
  group common/services/spi/xmega_spi
    ../../../../../../../../../common/services/spi/xmega_spi/: spi_master.c spi_master.h
  group common/services/sleepmgr
    ../../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/xmega
    ../../../../../../../../../common/services/sleepmgr/xmega/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../../../../../common/services/usb/: usb_atmel.h usb_protocol.h
  group common/services/usb/class/cdc
    ../../../../../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c udi_cdc_conf.h udi_cdc.h
  group common/services/usb/udc
    ../../../../../../../../../common/services/usb/udc/: udc.c udc_desc.h udc.h udd.h udi.h
  group common/services/ioport
    ../../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/xmega
    ../../../../../../../../../common/services/ioport/xmega/: ioport_compat.c ioport.h ioport_compat.h
  group common/services/gpio
    ../../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/xmega_gpio
    ../../../../../../../../../common/services/gpio/xmega_gpio/: xmega_gpio.h
  group common/services/delay
    ../../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/xmega
    ../../../../../../../../../common/services/delay/xmega/: cycle_counter.h
  group common/drivers/nvm
    ../../../../../../../../../common/drivers/nvm/: common_nvm.h
  group common/drivers/nvm/xmega
    ../../../../../../../../../common/drivers/nvm/xmega/: xmega_nvm.c
  group common/boards
    ../../../../../../../../../common/boards/: board.h
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c usb_device.h
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s nvm.h
  group xmega/drivers/spi
    ../../../../../../../../../xmega/drivers/spi/: spi.c spi.h
  group xmega/drivers/tc
    ../../../../../../../../../xmega/drivers/tc/: tc.c tc.h
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s xmega_reset_cause.h ccp.h
  group xmega/drivers/sleep
    ../../../../../../../../../xmega/drivers/sleep/: sleep.h
  group xmega/drivers/pmic
    ../../../../../../../../../xmega/drivers/pmic/: pmic.h
  group xmega/boards/xmega_rf212b_zigbit
    ../../../../../../../../../xmega/boards/xmega_rf212b_zigbit/: init.c xmega_rf212b_zigbit.h led.h
  group xmega/utils
    ../../../../../../../../../xmega/utils/: assembler.h status_codes.h compiler.h progmem.h
  group xmega/utils/preprocessor
    ../../../../../../../../../xmega/utils/preprocessor/: stringz.h mrepeat.h preprocessor.h tpaste.h
  group xmega/utils/bit_handling
    ../../../../../../../../../xmega/utils/bit_handling/: clz_ctz.h
  group xmega/utils/assembler
    ../../../../../../../../../xmega/utils/assembler/: iar.h
