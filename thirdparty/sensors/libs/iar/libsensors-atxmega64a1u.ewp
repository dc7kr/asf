# IAR project libsensors-atxmega64a1u.ewp, settings and files
configuration debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm64a1u ATxmega64A1U
  ICCAVR.CCDefines: BOARD=USER_BOARD
  ICCAVR.CCDiagSuppress: Pa050, Pa093, Pe188
  ICCAVR.newCCIncludePaths: ..\..\..\..\xmega\utils\; ..\..\..\..\xmega\utils\preprocessor\; ..\..\..\..\xmega\drivers\cpu\; ..\..\..\..\xmega\drivers\ioport\; ..\..\..\..\xmega\drivers\nvm\; ..\..\..\..\common\interrupt; ..\..\..\..\common\utils; ..\..\..\..\common\services; ..\..\..\..\common\services\gpio
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
configuration release (AVR)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-4s-xmega-n.h
  group driver
    ../../../../common/services/sensors/drivers/akm/: ak8975.c
    ../../../../common/services/sensors/drivers/bosch/: bma020.c bma150.c bma180.c bma220.c bma222.c bma250.c bmp.c
    ../../../../common/services/sensors/drivers/honeywell/: hmc5883l.c
    ../../../../common/services/sensors/drivers/invensense/: imu3000.c itg3200.c
    ../../../../common/services/sensors/drivers/kionix/: kxtf9.c
    ../../../../common/services/sensors/drivers/osram/: sfh5712.c sfh7770.c
