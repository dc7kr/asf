# IAR project fatfs_unit_tests_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM4S_EK2; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ..; ../../../../../sam/utils/preprocessor; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../sam/utils/cmsis/sam4s/include; ../../../../../sam/drivers/ebi/smc; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../sam/boards; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../sam/drivers/matrix; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/components/memory/nand_flash/nand_flash_ebi; ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../sam/boards/sam4s_ek2; ../..; ../../../../../common/services/gpio; ../../../../../common/services/storage/ecc_hamming; ../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../common/services/delay; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_unit_tests_sram.bin
  ILINK.IlinkOutputFile: fatfs_unit_tests_sram.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/: nand_flash_ecc_sw.c nand_flash_spare_scheme.c nand_flash_model.c nand_flash_raw_smc.c nand_flash_common.h nand_flash_spare_scheme.h nand_flash_ecc.h nand_flash_model.h nand_flash_raw.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c nand_flash_translation.h nand_flash_mem.h nand_flash_management.h
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm4.a
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/storage/ecc_hamming
    ../../../../../common/services/storage/ecc_hamming/: ecc-sw.c ecc-sw.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/sam4s
    ../../../../../common/services/clock/sam4s/: sysclk.c pll.h sysclk.h osc.h genclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/matrix
    ../../../../../sam/drivers/matrix/: matrix.c matrix.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/ebi/smc
    ../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/boards/sam4s_ek2
    ../../../../../sam/boards/sam4s_ek2/: init.c led.c led.h sam4s_ek2.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../sam/utils/cmsis/sam4s/include/: sam4s2b.h sam4s2a.h sam4s.h sam4s8b.h sam4sd16c.h sam4sa16c.h sam4s16b.h sam4sd32b.h sam4s4c.h sam4s16c.h sam4sd32c.h sam4s2c.h sam4s4a.h sam4sd16b.h sam4s4b.h sam4s8c.h sam4sa16b.h system_sam4s.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../sam/utils/cmsis/sam4s/include/component/: component_adc.h component_cmcc.h component_matrix.h component_efc.h component_pmc.h component_pio.h component_twi.h component_rtc.h component_acc.h component_uart.h component_wdt.h component_rstc.h component_supc.h component_spi.h component_dacc.h component_ssc.h component_pdc.h component_tc.h component_pwm.h component_usart.h component_hsmci.h component_smc.h component_chipid.h component_crccu.h component_rtt.h component_gpbr.h component_udp.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_rtc.h instance_crccu.h instance_piob.h instance_twi0.h instance_usart0.h instance_gpbr.h instance_wdt.h instance_pwm.h instance_usart1.h instance_dacc.h instance_chipid.h instance_udp.h instance_adc.h instance_smc.h instance_uart0.h instance_rstc.h instance_uart1.h instance_acc.h instance_tc0.h instance_ssc.h instance_hsmci.h instance_efc0.h instance_rtt.h instance_efc1.h instance_spi.h instance_supc.h instance_pioc.h instance_tc1.h instance_pioa.h instance_twi1.h instance_pmc.h instance_matrix.h instance_cmcc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4s2b.h pio_sam4s4c.h pio_sam4sd32c.h pio_sam4sa16c.h pio_sam4sd32b.h pio_sam4s16c.h pio_sam4sd16b.h pio_sam4s4b.h pio_sam4s8c.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4s8b.h pio_sam4s4a.h pio_sam4s2c.h pio_sam4s2a.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/unit_tests/sam4sd32c_sam4s_ek2
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_test.h conf_access.h conf_fatfs.h conf_nf.h
  group thirdparty/fatfs/unit_tests/sam4sd32c_sam4s_ek2/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
