# IAR project fatfs_access_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4N16C Atmel ATSAM4N16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4N_XPLAINED_PRO; ARM_MATH_CM4=true; __SAM4N16C__; AT45DBX_ENABLE
  ICCARM.CCIncludePath2: ../../../../../sam/utils/cmsis/sam4n/include; ../../../../../common/services/spi/sam_spi; ../../../../../sam/boards/sam4n_xplained_pro; ../../../../../sam/utils/cmsis/sam4n/source/templates; ../../../../../sam/utils/preprocessor; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../../sam/drivers/pio; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../sam/drivers/spi; ../..; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/gpio; ../../../../../common/services/serial/sam_uart; ..; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pmc; ../../../../../common/services/spi; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_access_example_flash.bin
  ILINK.IlinkOutputFile: fatfs_access_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam4n/sam4n16c/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/sam4n
    ../../../../../common/services/clock/sam4n/: sysclk.c pll.h genclk.h osc.h sysclk.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c at45dbx.h at45dbx_hal_spi.h at45dbx_mem.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4n/source/templates
    ../../../../../sam/utils/cmsis/sam4n/source/templates/: system_sam4n.c exceptions.c system_sam4n.h exceptions.h
  group sam/utils/cmsis/sam4n/source/templates/iar
    ../../../../../sam/utils/cmsis/sam4n/source/templates/iar/: startup_sam4n.c
  group sam/utils/cmsis/sam4n/include
    ../../../../../sam/utils/cmsis/sam4n/include/: sam4n.h sam4n8c.h sam4n16b.h sam4n8b.h sam4n16c.h sam4n8a.h
  group sam/utils/cmsis/sam4n/include/instance
    ../../../../../sam/utils/cmsis/sam4n/include/instance/: instance_wdt.h instance_twi0.h instance_twi2.h instance_matrix.h instance_tc0.h instance_usart1.h instance_pmc.h instance_gpbr.h instance_supc.h instance_dacc.h instance_pioa.h instance_uart2.h instance_usart0.h instance_uart1.h instance_usart2.h instance_pwm.h instance_rtt.h instance_chipid.h instance_spi.h instance_rstc.h instance_piob.h instance_efc.h instance_rtc.h instance_uart3.h instance_uart0.h instance_tc1.h instance_adc.h instance_pioc.h instance_twi1.h
  group sam/utils/cmsis/sam4n/include/component
    ../../../../../sam/utils/cmsis/sam4n/include/component/: component_rtc.h component_pwm.h component_uart.h component_rtt.h component_pmc.h component_pdc.h component_rstc.h component_usart.h component_supc.h component_adc.h component_wdt.h component_spi.h component_dacc.h component_efc.h component_pio.h component_matrix.h component_twi.h component_gpbr.h component_tc.h component_chipid.h
  group sam/utils/cmsis/sam4n/include/pio
    ../../../../../sam/utils/cmsis/sam4n/include/pio/: pio_sam4n16b.h pio_sam4n8c.h pio_sam4n16c.h pio_sam4n8a.h pio_sam4n8b.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4n_xplained_pro
    ../../../../../sam/boards/sam4n_xplained_pro/: init.c sam4n_xplained_pro.h led.h
  group thirdparty/fatfs/example
    ../../: fatfs_access_example.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/example/sam4n16c_sam4n_xplained_pro
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_at45dbx.h conf_spi_master.h conf_access.h conf_fatfs.h
  group thirdparty/fatfs/example/sam4n16c_sam4n_xplained_pro/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
