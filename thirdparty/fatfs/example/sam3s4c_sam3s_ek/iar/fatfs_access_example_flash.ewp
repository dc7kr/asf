# IAR project fatfs_access_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK; AT45DBX_ENABLE
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../../common/services/spi/sam_spi; ../../../../../sam/utils/preprocessor; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../common/services/serial; ../../../../../sam/drivers/spi; ../..; ../../../../../common/utils; ../../../../../sam/utils/cmsis/sam3s/source/templates; ..; ../../../../../sam/boards/sam3s_ek; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/services/gpio; ../../../../../sam/drivers/uart; ../../../../../sam/utils/cmsis/sam3s/include; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../common/services/spi; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK; AT45DBX_ENABLE
  OBJCOPY.OOCOutputFile: fatfs_access_example_flash.bin
  ILINK.IlinkOutputFile: fatfs_access_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c
  group sam/boards/sam3s_ek
    ../../../../../sam/boards/sam3s_ek/: init.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../sam/utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime.c
  group thirdparty/fatfs/example
    ../../: fatfs_access_example.c memories_initialization_sam.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
