# IAR project fatfs_access_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__; AT45DBX_ENABLE
  ICCARM.CCIncludePath2: ..; ../../../../../common/services/serial/sam_uart; ../../../../../common/services/spi/sam_spi; ../../../../../sam/utils/preprocessor; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../common/services/serial; ../../../../../common/services/ioport; ../../../../../sam/utils/cmsis/sam3n/include; ../../../../../sam/drivers/spi; ../..; ../../../../../common/utils; ../../../../../common/services/clock; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../sam/boards/sam3n_ek; ../../../../../common/services/gpio; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ../../../../../common/services/spi; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_access_example_flash.bin
  ILINK.IlinkOutputFile: fatfs_access_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h genclk.h pll.h osc.h
  group common/services/clock/sam3n
    ../../../../../common/services/clock/sam3n/: sysclk.c osc.h sysclk.h pll.h genclk.h
  group common/services/spi
    ../../../../../common/services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c at45dbx.h at45dbx_hal_spi.h at45dbx_mem.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../sam/utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c system_sam3n.h exceptions.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../sam/utils/cmsis/sam3n/include/: sam3n00a.h sam3n4b.h sam3n0c.h sam3n00b.h sam3n2a.h sam3n.h sam3n4a.h sam3n0a.h sam3n1c.h sam3n2c.h sam3n1b.h sam3n2b.h sam3n4c.h sam3n0b.h sam3n1a.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../sam/utils/cmsis/sam3n/include/pio/: pio_sam3n0c.h pio_sam3n4a.h pio_sam3n0a.h pio_sam3n1c.h pio_sam3n2c.h pio_sam3n4c.h pio_sam3n2a.h pio_sam3n0b.h pio_sam3n00b.h pio_sam3n00a.h pio_sam3n2b.h pio_sam3n4b.h pio_sam3n1b.h pio_sam3n1a.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../sam/utils/cmsis/sam3n/include/component/: component_uart.h component_gpbr.h component_rtt.h component_usart.h component_rstc.h component_wdt.h component_tc.h component_dacc.h component_efc.h component_pmc.h component_matrix.h component_twi.h component_chipid.h component_pwm.h component_spi.h component_pio.h component_rtc.h component_supc.h component_pdc.h component_adc.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../sam/utils/cmsis/sam3n/include/instance/: instance_rtc.h instance_spi.h instance_pwm.h instance_gpbr.h instance_tc0.h instance_wdt.h instance_rtt.h instance_uart1.h instance_tc1.h instance_pmc.h instance_rstc.h instance_supc.h instance_usart1.h instance_twi1.h instance_adc.h instance_usart0.h instance_pioa.h instance_uart0.h instance_chipid.h instance_twi0.h instance_piob.h instance_dacc.h instance_efc.h instance_matrix.h instance_pioc.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam3n_ek
    ../../../../../sam/boards/sam3n_ek/: init.c led.c led.h sam3n_ek.h
  group thirdparty/fatfs/example
    ../../: fatfs_access_example.c memories_initialization_sam.c memories_initialization.h
  group thirdparty/fatfs/example/sam3n4c_sam3n_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_at45dbx.h conf_spi_master.h conf_access.h conf_fatfs.h
  group thirdparty/fatfs/example/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c diskio.h ff.h integer.h ffconf.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
