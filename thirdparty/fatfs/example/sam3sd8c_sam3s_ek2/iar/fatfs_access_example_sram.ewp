# IAR project fatfs_access_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; ARM_MATH_CM3=true; BOARD=SAM3S_EK2; AT45DBX_ENABLE
  ICCARM.CCIncludePath2: ../../../../../common/services/serial/sam_uart; ../../../../../common/services/spi/sam_spi; ../../../../../sam/utils/preprocessor; ../../../../../common/components/memory/data_flash/at45dbx; ../../../../../sam/drivers/pmc; ../../../fatfs-r0.09/src; ../../../fatfs-port-r0.09/sam; ../../../../../common/services/ioport; ../../../../../sam/drivers/ebi/smc; ../../../../../common/services/serial; ..; ../../../../../common/services/clock; ../../../../../sam/drivers/spi; ../..; ../../../../../common/utils; ../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../../../../sam/drivers/matrix; ../../../../../sam/boards; ../../../../../common/utils/stdio/stdio_serial; ../../../../../common/components/memory/nand_flash/nand_flash_ebi; ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../sam/boards/sam3s_ek2; ../../../../../common/services/gpio; ../../../../../common/services/storage/ecc_hamming; ../../../../../common/services/delay; ../../../../../sam/drivers/uart; ../../../../../sam/utils; ../../../../../sam/drivers/tc; ../../../../../sam/drivers/usart; ../../../../../sam/utils/header_files; ../../../../../common/boards; ../../../../../sam/drivers/rtc; ../../../../../sam/drivers/pio; ../../../../../sam/utils/cmsis/sam3s8/include; ../../../../../common/services/spi; ../../../../../common/services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fatfs_access_example_sram.bin
  ILINK.IlinkOutputFile: fatfs_access_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/: nand_flash_ecc_sw.c nand_flash_spare_scheme.c nand_flash_model.c nand_flash_raw_smc.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/: nand_flash_mem.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm3.a
  group common/components/memory/data_flash/at45dbx
    ../../../../../common/components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c
  group common/services/clock/sam3s
    ../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/services/storage/ecc_hamming
    ../../../../../common/services/storage/ecc_hamming/: ecc-sw.c
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c
  group common/services/spi/sam_spi
    ../../../../../common/services/spi/sam_spi/: spi_master.c
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../sam/utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/matrix
    ../../../../../sam/drivers/matrix/: matrix.c
  group sam/drivers/pmc
    ../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/ebi/smc
    ../../../../../sam/drivers/ebi/smc/: smc.c
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c
  group sam/boards/sam3s_ek2
    ../../../../../sam/boards/sam3s_ek2/: led.c init.c
  group thirdparty/fatfs/example
    ../../: fatfs_access_example.c memories_initialization_sam.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../fatfs-r0.09/src/option/: ccsbcs.c
