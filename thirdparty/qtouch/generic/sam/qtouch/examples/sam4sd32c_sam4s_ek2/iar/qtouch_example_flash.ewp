# IAR project qtouch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4SD32C Atmel SAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM4=true; _SNS1_SNSK1_SAME_PORT_; SNSK1=C; SNSK2=A; _SNS2_SNSK2_SAME_PORT_; SNS1=C; QT_DELAY_CYCLES=5; BOARD=SAM4S_EK2; _QTOUCH_; QT_NUM_CHANNELS=32; SNS2=A; _DEBUG_INTERFACE_; __SAM4SD32C__
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ..; ../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../include; ../../../../../../../../common/services/serial; ../../../../../../qdebug; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../common; ../../../../../../../../common/services/gpio; ../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../sam/boards/sam4s_ek2; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qtouch_example_flash.bin
  ILINK.IlinkOutputFile: qtouch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4s/sam4sd32/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../lib/iar/: libsam4s-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/examples
    ../../: qtouch_example.c
  group thirdparty/qtouch/generic/sam/qtouch/examples/sam4sd32c_sam4s_ek2
    ../: conf_uart_serial.h conf_clock.h QDebugSettings.h conf_board.h conf_example.h
  group thirdparty/qtouch/generic/sam/qtouch/examples/sam4sd32c_sam4s_ek2/iar
    ./: asf.h
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../common/: BitBangSPI_Master.c touch_qt_config.h BitBangSPI_Master.h
  group thirdparty/qtouch/generic/include
    ../../../../../include/: touch_api.h
  group thirdparty/qtouch/qdebug
    ../../../../../../qdebug/: QDebugTransport.c QDebug.c QDebug.h QDebugTransport.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: pll.h osc.h genclk.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../../../common/services/clock/sam4s/: sysclk.c sysclk.h genclk.h osc.h pll.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s4a.h sam4s4c.h sam4s8c.h sam4sd32b.h sam4s16b.h sam4sa16b.h sam4s2c.h sam4sa16c.h sam4s2a.h system_sam4s.h sam4sd16c.h sam4s8b.h sam4s.h sam4s4b.h sam4sd16b.h sam4sd32c.h sam4s16c.h sam4s2b.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_pio.h component_tc.h component_smc.h component_gpbr.h component_cmcc.h component_rtc.h component_dacc.h component_ssc.h component_rtt.h component_rstc.h component_uart.h component_chipid.h component_pwm.h component_usart.h component_pmc.h component_udp.h component_wdt.h component_supc.h component_crccu.h component_twi.h component_spi.h component_matrix.h component_pdc.h component_acc.h component_efc.h component_hsmci.h component_adc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4sd16b.h pio_sam4s2a.h pio_sam4sa16c.h pio_sam4s16c.h pio_sam4s8b.h pio_sam4s4b.h pio_sam4s2b.h pio_sam4s8c.h pio_sam4sd32c.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s16b.h pio_sam4sa16b.h pio_sam4sd16c.h pio_sam4s2c.h pio_sam4sd32b.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_cmcc.h instance_crccu.h instance_efc0.h instance_chipid.h instance_tc0.h instance_usart0.h instance_pmc.h instance_dacc.h instance_piob.h instance_twi0.h instance_hsmci.h instance_efc1.h instance_acc.h instance_spi.h instance_adc.h instance_ssc.h instance_tc1.h instance_pwm.h instance_udp.h instance_wdt.h instance_rtc.h instance_uart0.h instance_matrix.h instance_rstc.h instance_twi1.h instance_supc.h instance_uart1.h instance_rtt.h instance_usart1.h instance_gpbr.h instance_pioa.h instance_pioc.h instance_smc.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/boards/sam4s_ek2
    ../../../../../../../../sam/boards/sam4s_ek2/: led.c sam4s_ek2.h led.h
