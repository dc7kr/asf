# IAR project qtouch_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _SNS1_SNSK1_SAME_PORT_; _SNS2_SNSK2_SAME_PORT_; BOARD=SAM3X_EK; ARM_MATH_CM3=true; SNSK2=E; __SAM3X8H__; SNSK1=F; _QTOUCH_; SNS2=E; SNS1=F
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/boards/sam3x_ek; ..; ../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../include; ../../../../../../../../common/services/serial; ../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../qdebug; ../../../../../../../../common/utils; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../common; ../../../../../../../../common/services/gpio; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qtouch_example_sram.bin
  ILINK.IlinkOutputFile: qtouch_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../lib/iar/: libsam3x-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/examples
    ../../: qtouch_example.c
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../common/: BitBangSPI_Master.c
  group thirdparty/qtouch/qdebug
    ../../../../../../qdebug/: QDebugTransport.c QDebug.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/sam3x_ek
    ../../../../../../../../sam/boards/sam3x_ek/: led.c
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/services/clock/sam3x
    ../../../../../../../../common/services/clock/sam3x/: sysclk.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
