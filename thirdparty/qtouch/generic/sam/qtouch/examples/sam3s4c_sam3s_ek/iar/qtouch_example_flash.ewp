# IAR project qtouch_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _SNS1_SNSK1_SAME_PORT_; SNSK1=C; SNSK2=A; _SNS2_SNSK2_SAME_PORT_; SNS1=C; QT_DELAY_CYCLES=5; __SAM3S4C__; ARM_MATH_CM3=true; _QTOUCH_; QT_NUM_CHANNELS=32; SNS2=A; BOARD=SAM3S_EK; _DEBUG_INTERFACE_
  ICCARM.CCIncludePath2: ../../../../../../../../common/services/serial/sam_uart; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ..; ../../../../../include; ../../../../../../../../sam/utils/cmsis/sam3s/include; ../../../../../../qdebug; ../../../../../../../../common/utils; ../../../../../../../../sam/utils/cmsis/sam3s/source/templates; ../../../../../../../../sam/drivers/wdt; ../../../../../../../../sam/boards/sam3s_ek; ../../../../../../../../common/services/clock; ../../../../../../../../sam/boards; ../../../../../../../../common/utils/stdio/stdio_serial; ../../../common; ../../../../../../../../common/services/gpio; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../common/boards; ../../../../../../../../sam/drivers/pio; ../../../../../../../../common/services/serial; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qtouch_example_flash.bin
  ILINK.IlinkOutputFile: qtouch_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/qtouch/generic/sam/qtouch/lib/iar
    ../../../lib/iar/: libsam3s-32qt-k-8rs-iar.a
  group thirdparty/qtouch/generic/sam/qtouch/examples
    ../../: qtouch_example.c
  group thirdparty/qtouch/generic/sam/qtouch/common
    ../../../common/: BitBangSPI_Master.c
  group thirdparty/qtouch/qdebug
    ../../../../../../qdebug/: QDebugTransport.c QDebug.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3s/source/templates/: exceptions.c system_sam3s.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/boards/sam3s_ek
    ../../../../../../../../sam/boards/sam3s_ek/: led.c
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common/services/clock/sam3s
    ../../../../../../../../common/services/clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c
