# IAR project macsc_example2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_MEGA_RF
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: ../../../../../boards/stk600; ../../../../cpu; ../../../../../utils; ../../../../../../common/services/clock; ..; ../../../../../../common/boards; ../../../../sleep; ../../../../../../common/services/ioport; ../../../../../../common/services/gpio; ../../../../../../common/utils; ../../../../usart; ../..; ../../../../../boards/stk600/rc128x_rfx; ../../..; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_MEGA_RF
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm2560.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_MEGA_RF
  group mega/boards/stk600/rc128x_rfx
    ../../../../../boards/stk600/rc128x_rfx/: init.c
  group mega/drivers/usart
    ../../../../usart/: usart_megarf.c
  group mega/drivers/macsc
    ../../../: macsc_megarf.c
  group mega/drivers/macsc/example2
    ../../: macsc_megarf_example2.c
  group common/services/clock/mega
    ../../../../../../common/services/clock/mega/: sysclk.c
