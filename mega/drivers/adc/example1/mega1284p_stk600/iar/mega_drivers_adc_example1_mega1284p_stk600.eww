<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mega_drivers_adc_example1_mega1284p_stk600.ewp</path>
	</project>
</workspace>
