<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\mega_drivers_adc_example1_mega88a_stk600.ewp</path>
	</project>
</workspace>
