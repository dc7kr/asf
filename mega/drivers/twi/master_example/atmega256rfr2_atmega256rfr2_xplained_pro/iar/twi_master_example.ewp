# IAR project twi_master_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/delay; ../../../../cpu; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/boards; ..; ../../../../../../common/services/ioport; ../../../../../../common/utils; ../../../../../boards/atmega256rfr2_xplained_pro; ../../../../../../common/services/gpio; ../../..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=ATMEGA256RFR2_XPLAINED_PRO
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../boards/atmega256rfr2_xplained_pro/: init.c
  group mega/drivers/twi
    ../../../: twi_megarf.c
  group mega/drivers/twi/master_example
    ../../: twi_master_example.c
  group common/services/clock/mega
    ../../../../../../common/services/clock/mega/: sysclk.c
