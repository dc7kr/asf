# IAR project twi_unit_tests.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x40
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m256rfr2 ATmega256RFR2
  ICCAVR.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../common/services/serial/megarf_usart; ../../../../cpu; ../../../../../utils; ../../../../../../common/services/clock; ../../../../../boards; ../../../../../../common/utils/stdio/stdio_serial; ../../../../../../common/boards; ../../../../../../common/services/ioport; ../../../../../../common/services/delay; ../..; ../../../../../boards/atmega256rfr2_xplained_pro; ../../../../../../common/utils; ../../../../usart; ../../..; ../../../../../../common/services/gpio; ..; ../../../../../../common/services/serial; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=ATMEGA256RFR2_XPLAINED_PRO
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../common/utils/unit_test/: suite.c
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common/services/clock/mega
    ../../../../../../common/services/clock/mega/: sysclk.c
  group mega/drivers/usart
    ../../../../usart/: usart_megarf.c
  group mega/drivers/twi
    ../../../: twi_megarf.c
  group mega/drivers/twi/unit_tests
    ../../: unit_tests.c
  group mega/boards/atmega256rfr2_xplained_pro
    ../../../../../boards/atmega256rfr2_xplained_pro/: init.c
