# IAR project stdio_usb_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK; ARM_MATH_CM3=true; UDD_ENABLE
  ICCARM.CCIncludePath2: ../../../../../../services/usb/class/cdc/device; ..; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/utils/cmsis/sam3s/include; ../../..; ../../../../../../services/sleepmgr; ../../../../..; ../../../../../../../sam/utils/cmsis/sam3s/source/templates; ../../../../../../services/usb/class/cdc; ../../../../../../../sam/boards/sam3s_ek; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../sam/drivers/udp; ../../../../../../services/gpio; ../../../../../../../sam/utils; ../..; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK; ARM_MATH_CM3=true; UDD_ENABLE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: stdio_usb_example_flash.bin
  ILINK.IlinkOutputFile: stdio_usb_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../: stdio_usb.c
  group common/utils/stdio/stdio_usb/stdio_usb_example
    ../../: stdio_usb_example.c
  group common/utils/interrupt
    ../../../../../interrupt/: interrupt_sam_nvic.c
  group common/services/usb/class/cdc/device
    ../../../../../../services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/sleepmgr/sam
    ../../../../../../services/sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam3s
    ../../../../../../services/clock/sam3s/: sysclk.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../../sam/utils/cmsis/sam3s/source/templates/: exceptions.c system_sam3s.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/udp
    ../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam3s_ek
    ../../../../../../../sam/boards/sam3s_ek/: init.c led.c
