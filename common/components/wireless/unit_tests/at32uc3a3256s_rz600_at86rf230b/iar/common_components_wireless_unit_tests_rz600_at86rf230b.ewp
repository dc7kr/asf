# IAR project common_components_wireless_unit_tests_rz600_at86rf230b.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=RZ600; UDD_ENABLE; EXT_BOARD=RZ600_AT86RF230B
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../services/usb/class/cdc/device; ../../../../../../avr32/drivers/usbb; ../../../../../../avr32/boards; ../../../../../services/spi/uc3_spi; ../../..; ../../../../../../avr32/drivers/pm; ../..; ../../../../../services/clock; ../../../../../utils/stdio/stdio_usb; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/gpio; ../../../../../services/sleepmgr; ../../../../../utils; ../../../../../../avr32/boards/rz600; ../../../../../../avr32/drivers/spi; ../../../../../services/usb/class/cdc; ..; ../../../../../services/usb/udc; ../../../../../services/usb; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../services/spi; ../../../../../boards; ../../../../../../avr32/drivers/flashc; ../../../../../../avr32/utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3a3/256s/iar/lnkuc3a3256s.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/utils/stdio
    ../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../../utils/stdio/stdio_usb/: stdio_usb.c
  group common/utils/unit_test
    ../../../../../utils/unit_test/: suite.c
  group common/components/wireless
    ../../../: at86rfx_driver.c
  group common/components/wireless/unit_tests
    ../../: unit_tests.c
  group common/components/wireless/at86rf230b
    ../../../at86rf230b/: at86rf230b.c
  group common/services/usb/class/cdc/device
    ../../../../../services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/udc
    ../../../../../services/usb/udc/: udc.c
  group common/services/sleepmgr/uc3
    ../../../../../services/sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3a3_a4
    ../../../../../services/clock/uc3a3_a4/: sysclk.c
  group common/services/spi/uc3_spi
    ../../../../../services/spi/uc3_spi/: spi_master.c
  group avr32/drivers/pm
    ../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/flashc
    ../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/usbb
    ../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/spi
    ../../../../../../avr32/drivers/spi/: spi.c
  group avr32/boards/rz600
    ../../../../../../avr32/boards/rz600/: init.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
