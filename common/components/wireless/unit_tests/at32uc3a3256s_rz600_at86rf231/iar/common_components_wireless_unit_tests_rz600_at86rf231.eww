<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_components_wireless_unit_tests_rz600_at86rf231.ewp</path>
	</project>
</workspace>
