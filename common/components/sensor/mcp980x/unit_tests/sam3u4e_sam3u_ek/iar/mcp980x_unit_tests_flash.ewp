# IAR project mcp980x_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3U4E__; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../services/serial/sam_uart; ../../../../../../../sam/utils/cmsis/sam3u/source/templates; ..; ../../../../../../../sam/utils/preprocessor; ../../..; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/pmc; ../../../../../../services/twi; ../../../../../../services/serial; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/boards/sam3u_ek; ../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../services/gpio; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../services/ioport; ../..; ../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mcp980x_unit_tests_flash.bin
  ILINK.IlinkOutputFile: mcp980x_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/clock/sam3u
    ../../../../../../services/clock/sam3u/: sysclk.c
  group common/components/sensor/mcp980x
    ../../../: mcp980x.c
  group common/components/sensor/mcp980x/unit_tests
    ../../: unit_tests.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/drivers/twi
    ../../../../../../../sam/drivers/twi/: twi.c
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/boards/sam3u_ek
    ../../../../../../../sam/boards/sam3u_ek/: init.c led.c
