# IAR project sd_mmc_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../xmega/drivers/pmic; ../../../../../../services/clock; ../../../../../../services/gpio; ../../../../../../services/spi; ../../../../../../services/serial; ../../../../../../boards; ../../../../../../services/serial/xmega_usart; ../../../../../../../xmega/utils; ../../../../../../../xmega/boards/xmega_c3_xplained; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/boards; ../../../../../../../xmega/drivers/nvm; ..; ../../../../../../utils; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/ioport; ../..; ../../../../../../services/delay; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc.c
  group common/components/memory/sd_mmc/example1
    ../../: example.c time_tick_xmega.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_c3_xplained
    ../../../../../../../xmega/boards/xmega_c3_xplained/: init.c
