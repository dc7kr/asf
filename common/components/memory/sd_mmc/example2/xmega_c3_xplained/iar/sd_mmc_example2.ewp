# IAR project sd_mmc_example2.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x600
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm384c3 ATxmega384C3
  ICCAVR.CCDefines: SD_MMC_ENABLE; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../..; ../../../../../../../xmega/drivers/pmic; ../../../../../../../xmega/utils; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../xmega/drivers/usart; ../..; ../../../../../../services/calendar; ../../../../../../services/serial; ../../../../../../../xmega/utils/preprocessor; ../../../../../../services/serial/xmega_usart; ..; ../../../../../../../xmega/drivers/nvm; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/xmega; ../../../../../../../xmega/boards; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../xmega/boards/xmega_c3_xplained; ../../../../../../services/spi; ../../../../../../boards; ../../../../../../../xmega/drivers/rtc; ../../../../../../services/ioport; ../../../../../../../xmega/drivers/sleep; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: SD_MMC_ENABLE; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; SD_MMC_ENABLE; BOARD=XMEGA_C3_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_mem.c sd_mmc_spi.c sd_mmc.c
  group common/components/memory/sd_mmc/example2
    ../../: example.c
  group common/services/calendar
    ../../../../../../services/calendar/: calendar.c
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c
  group common/services/sleepmgr/xmega
    ../../../../../../services/sleepmgr/xmega/: sleepmgr.c
  group common/services/spi/xmega_usart_spi
    ../../../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/xmega
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/xmega/: fattime.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/rtc
    ../../../../../../../xmega/drivers/rtc/: rtc.c
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_c3_xplained
    ../../../../../../../xmega/boards/xmega_c3_xplained/: init.c
