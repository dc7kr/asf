# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; SD_MMC_ENABLE; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../..; ../../../../../../services/serial/sam_uart; ../../../../../../services/spi/sam_spi; ../../../../../../../sam/utils/preprocessor; ../../../../../../../sam/drivers/pmc; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../..; ../../../../../../services/serial; ../../../../../../../sam/drivers/rtc; ../../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../../sam/drivers/spi; ../../../../../../utils; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../utils/stdio/stdio_serial; ../../../../../../../sam/boards/sam3n_ek; ../../../../../../services/gpio; ../../../../../../services/delay; ../../../../../../../sam/drivers/uart; ../../../../../../../sam/utils; ..; ../../../../../../../sam/drivers/usart; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pio; ../../../../../../services/spi; ../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/storage/ctrl_access
    ../../../../../../services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/sam3n
    ../../../../../../services/clock/sam3n/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc.h sd_mmc_spi.h sd_mmc_protocol.h sd_mmc_mem.h
  group common/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common/components/memory/sd_mmc/example2/sam3n4c_sam3n_ek
    ../: conf_uart_serial.h conf_clock.h conf_board.h conf_sd_mmc.h conf_example.h conf_spi_master.h
  group common/components/memory/sd_mmc/example2/sam3n4c_sam3n_ek/iar
    ./: asf.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/boards
    ../../../../../../boards/: board.h
  group sam/boards/sam3n_ek
    ../../../../../../../sam/boards/sam3n_ek/: led.c init.c led.h sam3n_ek.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c exceptions.h system_sam3n.h
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/cmsis/sam3n/include
    ../../../../../../../sam/utils/cmsis/sam3n/include/: sam3n00b.h sam3n2a.h sam3n1a.h sam3n0b.h sam3n2c.h sam3n1c.h sam3n4b.h sam3n.h sam3n2b.h sam3n0a.h sam3n0c.h sam3n4c.h sam3n00a.h sam3n4a.h sam3n1b.h
  group sam/utils/cmsis/sam3n/include/pio
    ../../../../../../../sam/utils/cmsis/sam3n/include/pio/: pio_sam3n2c.h pio_sam3n2a.h pio_sam3n4a.h pio_sam3n0c.h pio_sam3n1b.h pio_sam3n4c.h pio_sam3n2b.h pio_sam3n0b.h pio_sam3n1a.h pio_sam3n0a.h pio_sam3n1c.h pio_sam3n4b.h pio_sam3n00a.h pio_sam3n00b.h
  group sam/utils/cmsis/sam3n/include/instance
    ../../../../../../../sam/utils/cmsis/sam3n/include/instance/: instance_matrix.h instance_twi1.h instance_dacc.h instance_adc.h instance_rstc.h instance_efc.h instance_gpbr.h instance_wdt.h instance_pmc.h instance_supc.h instance_twi0.h instance_spi.h instance_rtt.h instance_usart0.h instance_tc0.h instance_chipid.h instance_uart1.h instance_pioa.h instance_pwm.h instance_pioc.h instance_usart1.h instance_tc1.h instance_rtc.h instance_uart0.h instance_piob.h
  group sam/utils/cmsis/sam3n/include/component
    ../../../../../../../sam/utils/cmsis/sam3n/include/component/: component_rstc.h component_wdt.h component_dacc.h component_usart.h component_pmc.h component_pio.h component_matrix.h component_adc.h component_uart.h component_supc.h component_pwm.h component_chipid.h component_pdc.h component_tc.h component_efc.h component_rtt.h component_twi.h component_spi.h component_rtc.h component_gpbr.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/rtc
    ../../../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/uart
    ../../../../../../../sam/drivers/uart/: uart.c uart.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h integer.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
