<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_components_memory_data_flash_at45dbx_example_stk600-rc064x_atxmega256a3u.ewp</path>
	</project>
</workspace>
