# IAR project common_components_memory_data_flash_at45dbx_example_stk600-rc064x_atxmega256a3u.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3u ATxmega256A3U
  ICCAVR.CCDefines: BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../services/clock; ../../../../../../../../xmega/boards/stk600/rc064x; ../../../../../../../../xmega/drivers/ioport; ../../../../../../../../xmega/drivers/cpu; ../../../../../../../services/spi; ../../../../../../../boards; ../../..; ../../../../../../../../xmega/utils; ../../../../../../../../xmega/drivers/spi; ../../../../../../../services/spi/xmega_spi; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/boards; ../../../../../../../../xmega/drivers/nvm; ../../../../../../../utils; ../../../../../../../services/gpio; ..; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC064X; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_spi
    ../../../../../../../services/spi/xmega_spi/: spi_master.c
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c
  group common/components/memory/data_flash/at45dbx/example
    ../../: at45dbx_example.c
  group xmega/boards/stk600/rc064x
    ../../../../../../../../xmega/boards/stk600/rc064x/: init.c
  group xmega/drivers/spi
    ../../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/nvm
    ../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/ioport
    ../../../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
