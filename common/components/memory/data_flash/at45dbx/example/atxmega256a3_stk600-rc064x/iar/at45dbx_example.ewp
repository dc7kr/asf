# IAR project at45dbx_example.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../xmega/boards/stk600/rc064x; ../../../../../../../services/spi/xmega_spi; ..; ../../../../../../../services/spi; ../../../../../../../boards; ../../../../../../../services/ioport; ../../..; ../../../../../../../../xmega/utils; ../../../../../../../../xmega/drivers/spi; ../../../../../../../services/clock; ../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../xmega/drivers/cpu; ../../../../../../../../xmega/boards; ../../../../../../../utils; ../../../../../../../services/gpio; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC064X; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/clock/xmega
    ../../../../../../../services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/spi/xmega_spi
    ../../../../../../../services/spi/xmega_spi/: spi_master.c
  group common/components/memory/data_flash/at45dbx
    ../../../: at45dbx.c
  group common/components/memory/data_flash/at45dbx/example
    ../../: at45dbx_example.c
  group xmega/boards/stk600/rc064x
    ../../../../../../../../xmega/boards/stk600/rc064x/: init.c
  group xmega/drivers/spi
    ../../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/cpu
    ../../../../../../../../xmega/drivers/cpu/: ccp.s
