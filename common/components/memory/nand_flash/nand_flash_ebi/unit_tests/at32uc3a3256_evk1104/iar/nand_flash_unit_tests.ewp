# IAR project nand_flash_unit_tests.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x4000
  General.GCStackSize: 0x1000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: _ASSERT_ENABLE_; BOARD=EVK1104; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../..; ../../../../../../../../avr32/boards; ../../../../../../../../avr32/utils/debug; ../../../../../../../services/serial; ../../../../../../../../avr32/boards/evk1104; ../../../../../../../../avr32/utils; ../../../../../../../../avr32/drivers/gpio; ../../../../../../../utils; ../../../../../../../../avr32/drivers/ecchrs; ../../../../../../../services/clock; ../../../../../../../utils/stdio/stdio_serial; ../../..; ../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../../services/storage/ecc_hamming; ../../../../../../../services/delay; ../../../../../../../services/serial/uc3_usart; ../../../../../../../../avr32/drivers/ebi/smc; ../../../../../../../boards; ../../../../../../../../avr32/drivers/usart; ../../../../../../../../avr32/drivers/flashc; ../../../../../../../../avr32/utils/preprocessor; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 1
  ICCAVR32.CCOptStrategy: 2
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/usart
    ../../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/gpio
    ../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/ebi/smc
    ../../../../../../../../avr32/drivers/ebi/smc/: smc.c
  group avr32/drivers/flashc
    ../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/utils/debug
    ../../../../../../../../avr32/utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group avr32/boards/evk1104
    ../../../../../../../../avr32/boards/evk1104/: led.c init.c
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../: nand_flash_model.c nand_flash_spare_scheme.c nand_flash_raw_smc.c nand_flash_ecc_sw.c
  group common/components/memory/nand_flash/nand_flash_ebi/unit_tests
    ../../: unit_tests.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c
  group common/services/storage/ecc_hamming
    ../../../../../../../services/storage/ecc_hamming/: ecc-sw.c
  group common/services/clock/uc3a3_a4
    ../../../../../../../services/clock/uc3a3_a4/: sysclk.c
