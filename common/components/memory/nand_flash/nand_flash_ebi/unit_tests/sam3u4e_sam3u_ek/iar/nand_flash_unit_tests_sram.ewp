# IAR project nand_flash_unit_tests_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3U4E__; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../../../sam/utils/preprocessor; ../..; ../../../../../../../../sam/drivers/pio; ..; ../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../services/serial; ../../../../../../../utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../../sam/drivers/dmac; ../../../ftl_lib; ../../../../../../../../sam/utils/cmsis/sam3u/include; ../../..; ../../../../../../../services/gpio; ../../../../../../../services/storage/ecc_hamming; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../services/serial/sam_uart; ../../../../../../../boards; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/pmc; ../../../../../../../services/storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: nand_flash_unit_tests_sram.bin
  ILINK.IlinkOutputFile: nand_flash_unit_tests_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../: nand_flash_raw_nfc.c nand_flash_model.c nand_flash_spare_scheme.c nand_flash_ecc_sw.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib
    ../../../ftl_lib/: nand_flash_mem.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../ftl_lib/iar/: lib_nand_flash_cortexm3.a
  group common/components/memory/nand_flash/nand_flash_ebi/unit_tests
    ../../: unit_tests.c
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c
  group common/services/storage/ecc_hamming
    ../../../../../../../services/storage/ecc_hamming/: ecc-sw.c
  group common/services/storage/ctrl_access
    ../../../../../../../services/storage/ctrl_access/: ctrl_access.c
  group common/services/clock/sam3u
    ../../../../../../../services/clock/sam3u/: sysclk.c
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c
  group sam/boards/sam3u_ek
    ../../../../../../../../sam/boards/sam3u_ek/: led.c init.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/dmac
    ../../../../../../../../sam/drivers/dmac/: dmac.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/ebi/smc
    ../../../../../../../../sam/drivers/ebi/smc/: smc.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
