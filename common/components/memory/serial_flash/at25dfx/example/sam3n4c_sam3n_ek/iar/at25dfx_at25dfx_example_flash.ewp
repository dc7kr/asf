# IAR project at25dfx_at25dfx_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../../../../../sam/drivers/uart; ../..; ../../../../../../../../sam/utils; ../../../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../../../sam/boards; ../../../../../../../services/spi; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../services/clock; ../../../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../../../sam/drivers/pmc; ..; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/pio; ../../../../../../../../sam/boards/sam3n_ek; ../../../../../../../utils; ../../..; ../../../../../../../services/gpio; ../../../../../../../services/spi/sam_spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_at25dfx_example_flash.bin
  ILINK.IlinkOutputFile: at25dfx_at25dfx_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam3n_ek
    ../../../../../../../../sam/boards/sam3n_ek/: init.c led.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c
  group common/services/clock/sam3n
    ../../../../../../../services/clock/sam3n/: sysclk.c
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx_hal_spi.c at25dfx.c
  group common/components/memory/serial_flash/at25dfx/example
    ../../: at25dfx_example.c
