# IAR project at25dfx_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../services/serial/sam_uart; ../../../../../../../services/spi/sam_spi; ../../../../../../../boards; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../services/serial; ../../../../../../../../sam/drivers/spi; ../../../../../../../utils; ../../../../../../../../sam/boards/sam4l_ek; ../../../../../../../../sam/drivers/wdt; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ..; ../../../../../../../services/delay; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../../sam/drivers/flashcalw; ../../../../../../../services/ioport; ../../../../../../../../sam/drivers/bpm; ../../..; ../../../../../../../services/spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_unit_tests_flash.bin
  ILINK.IlinkOutputFile: at25dfx_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/spi
    ../../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h dfll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam4l
    ../../../../../../../services/clock/sam4l/: dfll.c osc.c sysclk.c pll.c pll.h sysclk.h osc.h dfll.h genclk.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_gpio.h
  group common/components/memory/serial_flash/at25dfx
    ../../../: at25dfx.c at25dfx_hal_spi.c at25dfx.h at25dfx_hal_spi.h
  group common/components/memory/serial_flash/at25dfx/unit_tests
    ../../: unit_tests.c
  group common/components/memory/serial_flash/at25dfx/unit_tests/sam4lc4c_sam4l_ek
    ../: conf_at25dfx.h conf_uart_serial.h conf_clock.h conf_board.h conf_spi_master.h conf_test.h
  group common/components/memory/serial_flash/at25dfx/unit_tests/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls4b.h sam4lc8b.h sam4lc8c.h sam4lc4a.h sam4l.h sam4lc2a.h sam4lc4c.h sam4lc2c.h sam4ls4a.h sam4ls2c.h sam4ls8c.h sam4ls4c.h sam4lc4b.h sam4lc2b.h sam4ls8a.h sam4ls2a.h sam4ls2b.h sam4ls8b.h sam4lc8a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_tc1.h instance_acifc.h instance_hflashc.h instance_freqm.h instance_eic.h instance_chipid.h instance_bpm.h instance_trng.h instance_smap.h instance_abdacb.h instance_aesa.h instance_catb.h instance_twis0.h instance_parc.h instance_wdt.h instance_spi.h instance_twim0.h instance_ast.h instance_usart0.h instance_crccu.h instance_usart3.h instance_bscif.h instance_gpio.h instance_usart2.h instance_twim2.h instance_scif.h instance_adcife.h instance_lcdca.h instance_twis1.h instance_pevc.h instance_picouart.h instance_iisc.h instance_twim1.h instance_usart1.h instance_hcache.h instance_tc0.h instance_twim3.h instance_dacc.h instance_pdca.h instance_pm.h instance_gloc.h instance_hmatrix.h instance_usbc.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc8c.h pio_sam4ls8c.h pio_sam4lc2b.h pio_sam4lc8a.h pio_sam4lc8b.h pio_sam4lc4a.h pio_sam4lc4c.h pio_sam4ls8a.h pio_sam4ls4b.h pio_sam4ls4a.h pio_sam4ls2c.h pio_sam4ls4c.h pio_sam4ls2a.h pio_sam4lc4b.h pio_sam4lc2c.h pio_sam4lc2a.h pio_sam4ls8b.h pio_sam4ls2b.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_flashcalw.h component_usart.h component_freqm.h component_parc.h component_abdacb.h component_usbc.h component_adcife.h component_lcdca.h component_ast.h component_spi.h component_twim.h component_crccu.h component_gloc.h component_hmatrixb.h component_bscif.h component_bpm.h component_eic.h component_twis.h component_trng.h component_hcache.h component_gpio.h component_tc.h component_scif.h component_picouart.h component_pm.h component_pdca.h component_iisc.h component_dacc.h component_smap.h component_pevc.h component_aesa.h component_catb.h component_acifc.h component_chipid.h component_wdt.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/bpm
    ../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/flashcalw
    ../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/boards/sam4l_ek
    ../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c led.h sam4l_ek.h board_monitor.h
