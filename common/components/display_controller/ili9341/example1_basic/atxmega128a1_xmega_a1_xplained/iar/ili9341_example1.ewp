# IAR project ili9341_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../xmega/boards/xmega_a1_xplained; ../../../../../../services/delay; ../../../../../../../xmega/drivers/pmic; ../../../../../../services/clock; ../../../../../../../xmega/drivers/cpu; ../../../../../../services/spi; ../../../../../../boards; ../../../../../../../xmega/utils/preprocessor; ../../../../../../../xmega/utils; ../../..; ../../../../../../services/ioport; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/boards; ..; ../../../../../../utils; ../../../../../../services/gpio; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/components/display_controller/ili9341
    ../../../: ili9341.c
  group common/components/display_controller/ili9341/example1_basic
    ../../: ili9341_example.c
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group xmega/boards/xmega_a1_xplained
    ../../../../../../../xmega/boards/xmega_a1_xplained/: init.c
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s
