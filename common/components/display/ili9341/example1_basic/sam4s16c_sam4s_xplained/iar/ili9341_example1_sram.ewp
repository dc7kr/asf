# IAR project ili9341_example1_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../services/delay; ../../..; ../../../../../../services/spi/sam_spi; ..; ../../../../../../services/clock; ../../../../../../../sam/boards; ../../../../../../services/spi; ../../../../../../../sam/utils/header_files; ../../../../../../boards; ../../../../../../../sam/utils/preprocessor; ../../../../../../services/ioport; ../../../../../../../sam/drivers/pmc; ../../../../../../../sam/drivers/pio; ../../../../../../../sam/drivers/spi; ../../../../../../../sam/drivers/pdc; ../../../../../../utils; ../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../services/gpio; ../../../../../../../sam/utils; ../../../../../../../sam/boards/sam4s_xplained; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4S16C__; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ili9341_example1_sram.bin
  ILINK.IlinkOutputFile: ili9341_example1_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam4s_xplained
    ../../../../../../../sam/boards/sam4s_xplained/: init.c led.c led.h sam4s_xplained.h
  group sam/drivers/pmc
    ../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/pio
    ../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/spi
    ../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pdc
    ../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/utils
    ../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s16c.h sam4sd32c.h sam4s2b.h sam4s4b.h sam4sd32b.h system_sam4s.h sam4sd16b.h sam4s16b.h sam4sa16c.h sam4s8b.h sam4sd16c.h sam4s.h sam4s8c.h sam4sa16b.h sam4s4c.h sam4s2a.h sam4s4a.h sam4s2c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_adc.h instance_piob.h instance_udp.h instance_matrix.h instance_ssc.h instance_efc0.h instance_chipid.h instance_usart0.h instance_acc.h instance_rstc.h instance_hsmci.h instance_gpbr.h instance_twi0.h instance_efc1.h instance_rtt.h instance_usart1.h instance_supc.h instance_tc0.h instance_uart0.h instance_uart1.h instance_smc.h instance_pioa.h instance_rtc.h instance_pioc.h instance_tc1.h instance_cmcc.h instance_pmc.h instance_dacc.h instance_pwm.h instance_wdt.h instance_spi.h instance_crccu.h instance_twi1.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_twi.h component_acc.h component_pio.h component_spi.h component_hsmci.h component_rstc.h component_usart.h component_adc.h component_smc.h component_wdt.h component_udp.h component_pwm.h component_cmcc.h component_matrix.h component_efc.h component_supc.h component_gpbr.h component_ssc.h component_pmc.h component_dacc.h component_rtt.h component_crccu.h component_chipid.h component_rtc.h component_uart.h component_pdc.h component_tc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4s16b.h pio_sam4s4b.h pio_sam4sd16c.h pio_sam4s8b.h pio_sam4s2a.h pio_sam4sd32b.h pio_sam4s2c.h pio_sam4sa16b.h pio_sam4s2b.h pio_sam4sa16c.h pio_sam4sd32c.h pio_sam4sd16b.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s8c.h pio_sam4s16c.h
  group sam/utils/header_files
    ../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../sam/utils/preprocessor/: stringz.h mrepeat.h tpaste.h preprocessor.h
  group common/components/display/ili9341
    ../../../: ili9341.c ili9341_regs.h ili9341.h
  group common/components/display/ili9341/example1_basic
    ../../: ili9341_example.c
  group common/components/display/ili9341/example1_basic/sam4s16c_sam4s_xplained
    ../: conf_clock.h conf_board.h conf_spi_master.h conf_ili9341.h
  group common/components/display/ili9341/example1_basic/sam4s16c_sam4s_xplained/iar
    ./: asf.h
  group common/services/spi
    ../../../../../../services/spi/: spi_master.h
  group common/services/spi/sam_spi
    ../../../../../../services/spi/sam_spi/: spi_master.c spi_master.h
  group common/services/delay
    ../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../services/clock/: genclk.h pll.h sysclk.h osc.h
  group common/services/clock/sam4s
    ../../../../../../services/clock/sam4s/: sysclk.c genclk.h sysclk.h osc.h pll.h
  group common/services/ioport
    ../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../../services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../boards/: board.h
