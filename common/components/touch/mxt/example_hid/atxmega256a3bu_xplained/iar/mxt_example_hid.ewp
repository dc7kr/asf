# IAR project mxt_example_hid.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x1000
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../xmega/drivers/pmic; ../../../../../../../xmega/utils; ../../../../../../services/gfx; ../../../../../../services/gpio; ../../../../../../../xmega/utils/preprocessor; ../..; ../../../../../../../xmega/drivers/usart; ../../../../../../../xmega/drivers/nvm; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../..; ../../../../../../services/usb/class/hid/device/mouse; ../../../../../../services/clock; ../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../xmega/boards; ../../../../../../services/twi; ../../../../../../services/delay; ../../../../../display/ili9341; ../../../../../../../xmega/drivers/twi; ../../../../../../services/usb/class/hid/device; ../../../../../../../xmega/drivers/usb; ../../../../../../services/spi; ../../../../../../boards; ../../../../../../services/ioport; ..; ../../../../../../services/usb/class/hid; ../../../../../../../xmega/drivers/sleep; ../../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A3BU_XPLAINED; IOPORT_XMEGA_COMPAT
  group common/components/touch/mxt
    ../../../: mxt_device.c
  group common/components/touch/mxt/example_hid
    ../../: ui.c example_hid.c
  group common/components/display/ili9341
    ../../../../../display/ili9341/: ili9341.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/usb/class/hid/device
    ../../../../../../services/usb/class/hid/device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../../services/usb/class/hid/device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c
  group common/services/clock/xmega
    ../../../../../../services/clock/xmega/: sysclk.c
  group common/services/gfx
    ../../../../../../services/gfx/: gfx_text.c gfx_generic.c gfx_ili9341_sdt028atft.c sysfont.c
  group common/services/sleepmgr/xmega
    ../../../../../../services/sleepmgr/xmega/: sleepmgr.c
  group common/services/spi/xmega_usart_spi
    ../../../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group common/services/ioport/xmega
    ../../../../../../services/ioport/xmega/: ioport_compat.c
  group xmega/drivers/twi
    ../../../../../../../xmega/drivers/twi/: twis.c twim.c
  group xmega/drivers/nvm
    ../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usb
    ../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/usart
    ../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
