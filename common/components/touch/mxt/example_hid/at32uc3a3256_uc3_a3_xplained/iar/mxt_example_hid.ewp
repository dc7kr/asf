# IAR project mxt_example_hid.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: CONF_GFX_ILI9341_SDT028ATFT=1; UDD_ENABLE; BOARD=UC3_A3_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../avr32/boards; ../../../../../../services/spi/uc3_spi; ../../../../../../../avr32/drivers/twim; ../../../../../../../avr32/drivers/usbb; ../../../../../../../avr32/drivers/pm; ../../../../../../../avr32/drivers/eic; ../../../../../../services/gfx; ../..; ../../../../../../../avr32/utils; ../../../../../../../avr32/drivers/gpio; ..; ../../../../../../services/sleepmgr; ../../../../../../utils; ../../../../../../../avr32/drivers/spi; ../../..; ../../../../../../services/usb/class/hid/device/mouse; ../../../../../../services/clock; ../../../../../../services/usb/udc; ../../../../../../services/usb; ../../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../services/twi; ../../../../../../../avr32/boards/uc3_a3_xplained; ../../../../../../services/delay; ../../../../../display/ili9341; ../../../../../../services/usb/class/hid/device; ../../../../../../services/spi; ../../../../../../boards; ../../../../../../../avr32/drivers/flashc; ../../../../../../services/ioport; ../../../../../../../avr32/drivers/pdca; ../../../../../../../avr32/utils/preprocessor; ../../../../../../services/usb/class/hid; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/gfx
    ../../../../../../services/gfx/: sysfont.c gfx_text.c gfx_generic.c gfx_ili9341_sdt028atft.c
  group common/services/usb/class/hid/device
    ../../../../../../services/usb/class/hid/device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../../services/usb/class/hid/device/mouse/: udi_hid_mouse_desc.c udi_hid_mouse.c
  group common/services/usb/udc
    ../../../../../../services/usb/udc/: udc.c
  group common/services/clock/uc3a3_a4
    ../../../../../../services/clock/uc3a3_a4/: sysclk.c
  group common/services/sleepmgr/uc3
    ../../../../../../services/sleepmgr/uc3/: sleepmgr.c
  group common/services/spi/uc3_spi
    ../../../../../../services/spi/uc3_spi/: spi_master.c
  group common/components/touch/mxt
    ../../../: mxt_device.c
  group common/components/touch/mxt/example_hid
    ../../: ui.c example_hid.c
  group common/components/display/ili9341
    ../../../../../display/ili9341/: ili9341.c
  group avr32/drivers/spi
    ../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/flashc
    ../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/pm
    ../../../../../../../avr32/drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/gpio
    ../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/twim
    ../../../../../../../avr32/drivers/twim/: twim.c
  group avr32/drivers/pdca
    ../../../../../../../avr32/drivers/pdca/: pdca.c
  group avr32/drivers/eic
    ../../../../../../../avr32/drivers/eic/: eic.c
  group avr32/drivers/usbb
    ../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/boards/uc3_a3_xplained
    ../../../../../../../avr32/boards/uc3_a3_xplained/: init.c led.c
  group avr32/utils/startup
    ../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
