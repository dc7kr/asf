# IAR project qt_i2c_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4E16E Atmel ATSAM4E16E
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM4E_EK; ARM_MATH_CM4=true; __SAM4E16E__
  ICCARM.CCIncludePath2: ../../../../../../../services/serial/sam_uart; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../device_specific; ../../..; ..; ../../../../../../../../sam/utils/fpu; ../../../../../../../services/serial; ../../../../../../../../sam/utils/cmsis/sam4e/source/templates; ../../../../../../../utils; ../../../../../../../services/clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/utils/cmsis/sam4e/include; ../../../../../../../services/twi; ../../../../../../../services/delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../..; ../../../../../../../services/ioport; ../../../../../../../../sam/boards/sam4e_ek; ../../../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: qt_i2c_unit_tests_flash.bin
  ILINK.IlinkOutputFile: qt_i2c_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4e/sam4e16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/touch/qt/qt_i2c
    ../../../: qt_i2c.c qt_i2c.h
  group common/components/touch/qt/qt_i2c/unit_tests
    ../../: unit_tests.c
  group common/components/touch/qt/qt_i2c/unit_tests/sam4e16e_sam4e_ek
    ../: conf_qt_i2c.h conf_uart_serial.h conf_board.h conf_clock.h conf_test.h
  group common/components/touch/qt/qt_i2c/unit_tests/sam4e16e_sam4e_ek/iar
    ./: asf.h
  group common/components/touch/qt/qt_i2c/device_specific
    ../../../device_specific/: QT2160.h
  group common/utils
    ../../../../../../../utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c suite.h
  group common/services/delay
    ../../../../../../../services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../../../services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/sam4e
    ../../../../../../../services/clock/sam4e/: sysclk.c osc.h sysclk.h genclk.h pll.h
  group common/services/serial
    ../../../../../../../services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../services/serial/sam_uart/: uart_serial.h
  group common/services/twi
    ../../../../../../../services/twi/: twi_master.h twi_slave.h
  group common/services/twi/sam_twi
    ../../../../../../../services/twi/sam_twi/: twi_master.h twi_slave.h
  group common/services/ioport
    ../../../../../../../services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4e/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4e/source/templates/: exceptions.c system_sam4e.c system_sam4e.h exceptions.h
  group sam/utils/cmsis/sam4e/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4e/source/templates/iar/: startup_sam4e.c
  group sam/utils/cmsis/sam4e/include
    ../../../../../../../../sam/utils/cmsis/sam4e/include/: sam4e8c.h sam4e8e.h sam4e.h sam4e16c.h sam4e16e.h
  group sam/utils/cmsis/sam4e/include/component
    ../../../../../../../../sam/utils/cmsis/sam4e/include/component/: rstc.h supc.h acc.h spi.h tc.h pwm.h cmcc.h afec.h usart.h rtc.h udp.h pio.h aes.h efc.h pmc.h hsmci.h twi.h chipid.h crccu.h gmac.h matrix.h can.h wdt.h smc.h pdc.h dmac.h rswdt.h gpbr.h rtt.h uart.h dacc.h
  group sam/utils/cmsis/sam4e/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4e/include/instance/: twi1.h piob.h pwm.h udp.h can0.h chipid.h tc2.h pioe.h pmc.h dacc.h dmac.h pioc.h gpbr.h pioa.h tc0.h wdt.h hsmci.h gmac.h rtc.h smc.h afec1.h uart0.h usart0.h rstc.h can1.h aes.h efc.h crccu.h acc.h supc.h twi0.h afec0.h uart1.h spi.h rtt.h rswdt.h matrix.h cmcc.h tc1.h piod.h usart1.h
  group sam/utils/cmsis/sam4e/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4e/include/pio/: sam4e16e.h sam4e16c.h sam4e8e.h sam4e8c.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/twi
    ../../../../../../../../sam/drivers/twi/: twi.c twi.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/boards/sam4e_ek
    ../../../../../../../../sam/boards/sam4e_ek/: init.c sam4e_ek.h led.h
