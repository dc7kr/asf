# IAR project freertos_sam_spi_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM3N_EK; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../../../../../sam/utils/header_files; ../../../../../../spi/sam_spi; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ../../../../../../serial; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../../../sam/drivers/spi; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ..; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/boards/sam3n_ek; ../..; ../../../../../../gpio; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../../../sam/drivers/usart; ../../../../../../serial/sam_uart; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; ../../../../../../spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_spi_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_spi_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c FreeRTOS_CLI.c timers.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3/: port.c portasm.s
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/services/serial
    ../../../../../../serial/: usart_serial.c
  group common/services/clock/sam3n
    ../../../../../../clock/sam3n/: sysclk.c
  group common/services/spi/sam_spi
    ../../../../../../spi/sam_spi/: spi_master.c
  group common/services/freertos/sam
    ../../../../: freertos_spi_master.c freertos_peripheral_control.c
  group common/services/freertos/sam/unit_tests/freertos_spi_master
    ../../: spi_unit_tests.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/: system_sam3n.c exceptions.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam/boards/sam3n_ek
    ../../../../../../../../sam/boards/sam3n_ek/: init.c led.c
