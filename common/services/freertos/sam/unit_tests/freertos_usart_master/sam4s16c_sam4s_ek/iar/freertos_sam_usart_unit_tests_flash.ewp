# IAR project freertos_sam_usart_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; BOARD=SAM4S_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../serial/sam_uart; ../..; ../../../../../../../../sam/utils/preprocessor; ..; ../../../../../../../../sam/drivers/pmc; ../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../serial; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3; ../../../../../../../../sam/boards/sam4s_ek; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../gpio; ../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_usart_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_usart_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3/: port.c portasm.s
  group common/services/freertos/sam
    ../../../../: freertos_usart_serial.c freertos_peripheral_control.c
  group common/services/freertos/sam/unit_tests/freertos_usart_master
    ../../: usart_unit_tests.c
  group common/services/serial
    ../../../../../../serial/: usart_serial.c
  group common/services/clock/sam4s
    ../../../../../../clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_ek
    ../../../../../../../../sam/boards/sam4s_ek/: led.c init.c
