# IAR project freertos_sam_usart_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; __SAM3U4E__; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../serial/sam_uart; ../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../..; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ..; ../../../../../../serial; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/include; ../../../../../../../../sam/drivers/pdc; ../../../../../../../utils; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../gpio; ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../../../sam/utils/header_files; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: freertos_sam_usart_unit_tests_flash.bin
  ILINK.IlinkOutputFile: freertos_sam_usart_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/: tasks.c timers.c FreeRTOS_CLI.c list.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3
    ../../../../../../../../thirdparty/freertos/freertos-7.3.0/source/portable/iar/arm_cm3/: port.c portasm.s
  group common/services/freertos/sam
    ../../../../: freertos_usart_serial.c freertos_peripheral_control.c
  group common/services/freertos/sam/unit_tests/freertos_usart_master
    ../../: usart_unit_tests.c
  group common/services/clock/sam3u
    ../../../../../../clock/sam3u/: sysclk.c
  group common/services/serial
    ../../../../../../serial/: usart_serial.c
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group sam/boards/sam3u_ek
    ../../../../../../../../sam/boards/sam3u_ek/: led.c init.c
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
