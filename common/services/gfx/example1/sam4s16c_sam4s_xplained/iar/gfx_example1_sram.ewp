# IAR project gfx_example1_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; GFX_INITIALIZED=1; CONF_GFX_ILI9341_SDT028ATFT=1; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../delay; ../../../../../../sam/boards/sam4s_xplained; ../../..; ../../../../../../sam/utils; ../../../../clock; ../../../../../boards; ../../../../spi; ../../../../../../sam/utils/header_files; ..; ../../../../../../sam/utils/preprocessor; ../../../../../components/display_controller/ili9341; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/drivers/spi; ../../../../../../sam/boards; ../../../../../utils; ../../../../../../sam/utils/cmsis/sam4s/include; ../../../../gpio; ../../../../spi/sam_spi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: gfx_example1_sram.bin
  ILINK.IlinkOutputFile: gfx_example1_sram.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/gfx
    ../../../: gfx_text.c sysfont.c gfx_ili9341_sdt028atft.c gfx_generic.c
  group common/services/gfx/example1
    ../../: example1.c
  group common/services/spi/sam_spi
    ../../../../spi/sam_spi/: spi_master.c
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c
  group common/services/clock/sam4s
    ../../../../clock/sam4s/: sysclk.c
  group common/components/display_controller/ili9341
    ../../../../../components/display_controller/ili9341/: ili9341.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_xplained
    ../../../../../../sam/boards/sam4s_xplained/: init.c
