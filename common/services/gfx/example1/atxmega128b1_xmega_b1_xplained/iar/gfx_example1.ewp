# IAR project gfx_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; GFX_INITIALIZED=1; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../components/display_controller/ili9341; ../../../../delay; ../../..; ../../../../../../xmega/drivers/pmic; ../../../../clock; ../../../../gpio; ../../../../spi; ../../../../../../xmega/boards/xmega_b1_xplained; ../../../../../boards; ../../../../../../xmega/utils/preprocessor; ../../../../../../xmega/utils; ..; ../../../../ioport; ../../../../../../xmega/drivers/usart; ../../../../../../xmega/boards; ../../../../../../xmega/drivers/nvm; ../../../../../utils; ../../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; GFX_INITIALIZED=1; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  group common/components/display_controller/ili9341
    ../../../../../components/display_controller/ili9341/: ili9341.c
  group common/services/gfx
    ../../../: gfx_generic.c sysfont.c gfx_ili9341_sdt028atft.c gfx_text.c
  group common/services/gfx/example1
    ../../: example1.c
  group common/services/clock/xmega
    ../../../../clock/xmega/: sysclk.c
  group common/services/spi/xmega_usart_spi
    ../../../../spi/xmega_usart_spi/: usart_spi.c
  group common/services/ioport/xmega
    ../../../../ioport/xmega/: ioport_compat.c
  group xmega/drivers/usart
    ../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/nvm
    ../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_b1_xplained
    ../../../../../../xmega/boards/xmega_b1_xplained/: init.c
