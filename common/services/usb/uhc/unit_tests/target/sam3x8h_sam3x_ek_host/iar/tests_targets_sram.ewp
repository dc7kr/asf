# IAR project tests_targets_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ARM_MATH_CM3=true; UHD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../../../sam/drivers/uotghs; ../../../../../../../../sam/utils/header_files; ../../../../../class/hid/host/mouse; ../../../../../../../../sam/utils/preprocessor; ../../../../../../../../sam/drivers/pmc; ..; ../../../../../../../../sam/boards/sam3x_ek; ../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../serial; ../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../sleepmgr; ../../../../../../../utils; ../../../..; ../../../../../../clock; ../../../../../../../../sam/boards; ../../../../../../../utils/stdio/stdio_serial; ../..; ../../../../..; ../../../../../../gpio; ../../../../../../delay; ../../../../../../../../sam/drivers/uart; ../../../../../../../../sam/utils; ../../../../../../../../sam/drivers/usart; ../../../../../../serial/sam_uart; ../../../../../../../boards; ../../../../../../ioport; ../../../../../../../../sam/drivers/pio; ../../../../../class/hid; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: tests_targets_sram.bin
  ILINK.IlinkOutputFile: tests_targets_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/stdio
    ../../../../../../../utils/stdio/: read.c write.c
  group common/utils/unit_test
    ../../../../../../../utils/unit_test/: suite.c
  group common/services/sleepmgr/sam
    ../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/serial
    ../../../../../../serial/: usart_serial.c
  group common/services/delay/sam
    ../../../../../../delay/sam/: cycle_counter.c
  group common/services/usb/class/hid/host/mouse
    ../../../../../class/hid/host/mouse/: uhi_hid_mouse.c
  group common/services/usb/uhc
    ../../../../: uhc.c
  group common/services/usb/uhc/unit_tests/target
    ../../: unit_tests.c
  group common/services/clock/sam3x
    ../../../../../../clock/sam3x/: sysclk.c
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/uotghs
    ../../../../../../../../sam/drivers/uotghs/: uotghs_host.c
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/sam3x_ek
    ../../../../../../../../sam/boards/sam3x_ek/: led.c init.c
