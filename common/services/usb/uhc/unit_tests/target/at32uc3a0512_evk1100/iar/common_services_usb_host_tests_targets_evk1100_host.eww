<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_host_tests_targets_evk1100_host.ewp</path>
	</project>
</workspace>
