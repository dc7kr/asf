<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_host_tests_generator_evk1104.ewp</path>
	</project>
</workspace>
