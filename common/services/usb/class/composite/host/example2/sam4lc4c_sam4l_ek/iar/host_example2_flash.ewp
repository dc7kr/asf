# IAR project host_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../hid/host/mouse; ../../../../../../../../../sam/drivers/usbc; ../../../../../../../../../sam/utils/preprocessor; ..; ../../../../../msc; ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../..; ../../../../../../../../../sam/drivers/ast; ../../../../../../../../../sam/drivers/eic; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam/boards/sam4l_ek; ../../../../../../../../../sam/drivers/wdt; ../../../../../../uhc; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../..; ../../../../../../../../../sam/drivers/gpio; ../../../../../msc/host; ../../../../../../../delay; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../hid; ../../../../../../../../../sam/drivers/bpm; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: UHD_ENABLE; BOARD=SAM4L_EK; __SAM4LC4C__; ARM_MATH_CM4=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example2_flash.bin
  ILINK.IlinkOutputFile: host_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x1000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/hid
    ../../../../../hid/: usb_protocol_hid.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../hid/host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/class/msc
    ../../../../../msc/: spc_protocol.h usb_protocol_msc.h sbc_protocol.h
  group common/services/usb/class/msc/host
    ../../../../../msc/host/: uhi_msc.c uhi_msc_mem.c uhi_msc.h uhi_msc_mem.h
  group common/services/usb/class/composite/host/example2
    ../../: main.c conf_fatfs.h conf_access.h conf_usb_host.h main.h ui.h
  group common/services/usb/class/composite/host/example2/sam4lc4c_sam4l_ek
    ../: ui.c conf_ast.h conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/composite/host/example2/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c uhd.h uhi.h uhc.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/clock
    ../../../../../../../clock/: dfll.h pll.h genclk.h osc.h sysclk.h
  group common/services/clock/sam4l
    ../../../../../../../clock/sam4l/: pll.c dfll.c sysclk.c osc.c pll.h genclk.h osc.h dfll.h sysclk.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_gpio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam/boards/sam4l_ek
    ../../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c sam4l_ek.h board_monitor.h led.h
  group sam/drivers/flashcalw
    ../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/ast
    ../../../../../../../../../sam/drivers/ast/: ast.c ast.h
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/gpio
    ../../../../../../../../../sam/drivers/gpio/: gpio.c gpio.h
  group sam/drivers/wdt
    ../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/eic
    ../../../../../../../../../sam/drivers/eic/: eic.c eic.h
  group sam/drivers/bpm
    ../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/drivers/usbc
    ../../../../../../../../../sam/drivers/usbc/: usbc_host.c usbc_otg.h usbc_host.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: system_sam4l.c exceptions.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4ls2c.h sam4lc8c.h sam4l.h sam4lc2b.h sam4ls2a.h sam4lc4b.h sam4ls8c.h sam4lc4a.h sam4lc2c.h sam4lc2a.h sam4lc4c.h sam4lc8b.h sam4ls8b.h sam4ls4b.h sam4lc8a.h sam4ls2b.h sam4ls4a.h sam4ls4c.h sam4ls8a.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_gpio.h instance_spi.h instance_hflashc.h instance_twis1.h instance_usbc.h instance_pdca.h instance_bscif.h instance_hcache.h instance_parc.h instance_iisc.h instance_abdacb.h instance_picouart.h instance_gloc.h instance_catb.h instance_twis0.h instance_adcife.h instance_twim2.h instance_bpm.h instance_twim3.h instance_wdt.h instance_dacc.h instance_pm.h instance_usart3.h instance_hmatrix.h instance_usart1.h instance_chipid.h instance_freqm.h instance_aesa.h instance_twim1.h instance_twim0.h instance_crccu.h instance_tc1.h instance_eic.h instance_acifc.h instance_pevc.h instance_scif.h instance_trng.h instance_usart2.h instance_ast.h instance_lcdca.h instance_smap.h instance_usart0.h instance_tc0.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_tc.h component_gloc.h component_hcache.h component_adcife.h component_smap.h component_usbc.h component_gpio.h component_dacc.h component_trng.h component_wdt.h component_eic.h component_usart.h component_iisc.h component_lcdca.h component_abdacb.h component_twim.h component_acifc.h component_picouart.h component_freqm.h component_scif.h component_parc.h component_pevc.h component_hmatrixb.h component_ast.h component_flashcalw.h component_bscif.h component_chipid.h component_catb.h component_twis.h component_pdca.h component_spi.h component_bpm.h component_crccu.h component_pm.h component_aesa.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4lc8c.h pio_sam4lc2b.h pio_sam4ls8c.h pio_sam4ls2b.h pio_sam4ls8b.h pio_sam4ls4a.h pio_sam4lc2a.h pio_sam4lc4a.h pio_sam4lc2c.h pio_sam4lc4b.h pio_sam4ls2c.h pio_sam4ls4c.h pio_sam4ls2a.h pio_sam4lc4c.h pio_sam4lc8b.h pio_sam4ls4b.h pio_sam4lc8a.h pio_sam4ls8a.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_ast.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ffconf.h ff.h diskio.h integer.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
