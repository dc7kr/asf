# IAR project host_example2_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ..; ../../../../../../../../../sam/drivers/uotghs; ../../../../../hid/host/mouse; ../../../../../../../../../sam/utils/preprocessor; ../../../../../msc; ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../..; ../../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../uhc; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../..; ../../../../../../../gpio; ../../../../../../../ioport; ../../../../../msc/host; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../../../sam/drivers/rtc; ../../../../../../../../../sam/drivers/pio; ../../../../../hid; ../../../../../../../../../sam/boards/arduino_due_x; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example2_sram.bin
  ILINK.IlinkOutputFile: host_example2_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb/class/hid/host/mouse
    ../../../../../hid/host/mouse/: uhi_hid_mouse.c
  group common/services/usb/class/msc/host
    ../../../../../msc/host/: uhi_msc.c uhi_msc_mem.c
  group common/services/usb/class/composite/host/example2
    ../../: main.c
  group common/services/usb/class/composite/host/example2/sam3x8e_arduino_due_x
    ../: ui.c
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam3x
    ../../../../../../../clock/sam3x/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/rtc
    ../../../../../../../../../sam/drivers/rtc/: rtc.c
  group sam/drivers/uotghs
    ../../../../../../../../../sam/drivers/uotghs/: uotghs_host.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/arduino_due_x
    ../../../../../../../../../sam/boards/arduino_due_x/: led.c init.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam
    ../../../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam/: fattime_rtc.c
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
