<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_composite_host_example1_uc3c_ek.ewp</path>
	</project>
</workspace>
