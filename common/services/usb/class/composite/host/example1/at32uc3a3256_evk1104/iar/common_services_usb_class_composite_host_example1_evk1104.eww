<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_composite_host_example1_evk1104.ewp</path>
	</project>
</workspace>
