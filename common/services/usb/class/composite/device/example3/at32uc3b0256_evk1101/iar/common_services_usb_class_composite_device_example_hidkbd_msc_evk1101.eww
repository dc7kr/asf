<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_composite_device_example_hidkbd_msc_evk1101.ewp</path>
	</project>
</workspace>
