# IAR project device_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ACCESS_USB_ENABLED; UDD_ENABLE; __SAM4S16C__; VIRTUAL_MEMORY_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ..; ../..; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/drivers/udp; ../../../../../../../gpio; ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../..; ../../../../../../../../../sam/boards/sam4s_xplained; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: device_example_sram.bin
  ILINK.IlinkOutputFile: device_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/ebi/smc
    ../../../../../../../../../sam/drivers/ebi/smc/: smc.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_xplained
    ../../../../../../../../../sam/boards/sam4s_xplained/: init.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/example
    ../../: memories_initialization_sam.c main.c
  group common/services/usb/class/msc/device/example/sam4s16c_sam4s_xplained
    ../: ui.c
  group common/services/clock/sam4s
    ../../../../../../../clock/sam4s/: sysclk.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
