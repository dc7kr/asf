# IAR project common_services_usb_class_msc_device_example_stk600_atxmega128a1u.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128a1u ATxmega128A1U
  ICCAVR.CCDefines: BOARD=STK600_RC100X; ACCESS_USB_ENABLED; AT45DBX_ENABLE
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ..; ../../../../../../../../../xmega/boards/stk600/rc100x; ../../../../../../../spi/xmega_spi; ../..; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../xmega/utils; ../../../..; ../../../../../../../../../xmega/drivers/ioport; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../clock; ../../../../../../udc; ../../../../../..; ../../../../../../../../../xmega/boards; ../../../../../../../gpio; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../xmega/drivers/spi; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../xmega/drivers/cpu; ../../../../../../../storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: BOARD=STK600_RC100X; ACCESS_USB_ENABLED; AT45DBX_ENABLE
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=STK600_RC100X; ACCESS_USB_ENABLED; AT45DBX_ENABLE
  group xmega/boards/stk600/rc100x
    ../../../../../../../../../xmega/boards/stk600/rc100x/: init.c
  group xmega/drivers/ioport
    ../../../../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/spi
    ../../../../../../../../../xmega/drivers/spi/: spi.c
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/example
    ../../: main.c memories_initialization_xmega.c
  group common/services/usb/class/msc/device/example/atxmega128a1u_stk600-rc100x
    ../: ui.c
  group common/services/clock/xmega
    ../../../../../../../clock/xmega/: sysclk.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/spi/xmega_spi
    ../../../../../../../spi/xmega_spi/: spi_master.c
  group common/services/sleepmgr/xmega
    ../../../../../../../sleepmgr/xmega/: sleepmgr.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx_mem.c at45dbx.c
