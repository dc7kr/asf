# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ACCESS_USB_ENABLED; SD_MMC_ENABLE; UDD_ENABLE; TEST_SUITE_DEFINE_ASSERT_MACRO; __SAM3S4C__; ARM_MATH_CM3=true; VIRTUAL_MEMORY_ENABLE; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../../../../../components/memory/sd_mmc; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/utils/preprocessor; ../../../..; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../gpio; ../../../../../../../../../sam/utils/cmsis/sam3s/include; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../sam/utils/cmsis/sam3s/source/templates; ../../..; ../../../../../../../../../sam/boards/sam3s_ek; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../../sam/drivers/pdc; ../../../../../..; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/drivers/udp; ../..; ..; ../../../../../../../delay; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../udc; ../../../../../../../../../sam/drivers/usart; ../../../../../../../serial/sam_uart; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/drivers/hsmci; ../../../../../../../serial; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c
  group common/services/clock/sam3s
    ../../../../../../../clock/sam3s/: sysclk.c
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: read.c write.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/components/memory/sd_mmc
    ../../../../../../../../components/memory/sd_mmc/: sd_mmc_mem.c sd_mmc.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/hsmci
    ../../../../../../../../../sam/drivers/hsmci/: hsmci.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pdc
    ../../../../../../../../../sam/drivers/pdc/: pdc.c
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam3s_ek
    ../../../../../../../../../sam/boards/sam3s_ek/: init.c led.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3s/source/templates/: exceptions.c system_sam3s.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
