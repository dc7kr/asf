# IAR project common_services_usb_class_msc_device_unit_tests_atxmega256a3bu_xmega_a3bu_xplained.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm256a3bu ATxmega256A3BU
  ICCAVR.CCDefines: _ASSERT_ENABLE_; ACCESS_USB_ENABLED; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A3BU_XPLAINED; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; AT45DBX_ENABLE
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../../../../../xmega/drivers/pmic; ../../../../../../../../../xmega/drivers/ioport; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../xmega/utils; ../../../..; ../../../../../../../serial; ../../../../../../../../../xmega/drivers/usart; ../..; ../../../../../../../../../xmega/drivers/nvm; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../clock; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../../../xmega/boards; ..; ../../../../../../../gpio; ../../../../../../../../../xmega/boards/xmega_a3bu_xplained; ../../../../../../../../../xmega/drivers/usb; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../xmega/utils/preprocessor; ../../../../../../../../../xmega/drivers/sleep; ../../../../../../../../../xmega/drivers/cpu; ../../../../../../../storage/ctrl_access; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; _ASSERT_ENABLE_; ACCESS_USB_ENABLED; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=XMEGA_A3BU_XPLAINED; CONFIG_NVM_IGNORE_XMEGA_A3_D3_REVB_ERRATA; AT45DBX_ENABLE
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_xmega.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/spi/xmega_usart_spi
    ../../../../../../../spi/xmega_usart_spi/: usart_spi.c
  group common/services/clock/xmega
    ../../../../../../../clock/xmega/: sysclk.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c
  group common/services/sleepmgr/xmega
    ../../../../../../../sleepmgr/xmega/: sleepmgr.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx_mem.c at45dbx.c
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c
  group xmega/drivers/ioport
    ../../../../../../../../../xmega/drivers/ioport/: ioport.c
  group xmega/drivers/usart
    ../../../../../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/usb
    ../../../../../../../../../xmega/drivers/usb/: usb_device.c
  group xmega/drivers/nvm
    ../../../../../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/cpu
    ../../../../../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a3bu_xplained
    ../../../../../../../../../xmega/boards/xmega_a3bu_xplained/: init.c
