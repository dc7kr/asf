# IAR project device_unit_tests_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; ACCESS_USB_ENABLED; UDD_ENABLE; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO; VIRTUAL_MEMORY_ENABLE; __SAM3X8E__; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/drivers/uotghs; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ..; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../serial; ../../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../../sleepmgr; ../..; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../udc; ../../../../../..; ../../../../../../../../utils; ../../../../../../../gpio; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../serial/sam_uart; ../../../../../../../../boards; ../../../../../../../ioport; ../../../..; ../../../../../../../../../sam/boards/arduino_due_x; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_sram.bin
  ILINK.IlinkOutputFile: device_unit_tests_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c
  group common/services/clock/sam3x
    ../../../../../../../clock/sam3x/: sysclk.c
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uotghs
    ../../../../../../../../../sam/drivers/uotghs/: uotghs_device.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/arduino_due_x
    ../../../../../../../../../sam/boards/arduino_due_x/: init.c
