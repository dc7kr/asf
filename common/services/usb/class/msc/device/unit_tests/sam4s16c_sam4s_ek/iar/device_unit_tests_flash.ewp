# IAR project device_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAM4S16C__; _ASSERT_ENABLE_; ACCESS_USB_ENABLED; UDD_ENABLE; BOARD=SAM4S_EK; TEST_SUITE_DEFINE_ASSERT_MACRO; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../../../serial/sam_uart; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../serial; ../../../../../../../../../sam/boards; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../..; ../../../../../../../../../sam/boards/sam4s_ek; ../../../../../../../clock; ../../../../../../../../../sam/drivers/matrix; ../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../components/memory/nand_flash/nand_flash_ebi; ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/ftl_lib; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/udp; ../..; ../../../../../../../gpio; ../../../../../../../storage/ecc_hamming; ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../delay; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ..; ../../../..; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: device_unit_tests_flash.bin
  ILINK.IlinkOutputFile: device_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/components/memory/nand_flash/nand_flash_ebi
    ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/: nand_flash_spare_scheme.c nand_flash_raw_smc.c nand_flash_model.c nand_flash_ecc_sw.c
  group common/components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar
    ../../../../../../../../components/memory/nand_flash/nand_flash_ebi/ftl_lib/iar/: lib_nand_flash_cortexm4.a
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/unit_tests
    ../../: unit_tests.c memories_initialization_sam.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/storage/ecc_hamming
    ../../../../../../../storage/ecc_hamming/: ecc-sw.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/serial
    ../../../../../../../serial/: usart_serial.c
  group common/services/delay/sam
    ../../../../../../../delay/sam/: cycle_counter.c
  group common/services/clock/sam4s
    ../../../../../../../clock/sam4s/: sysclk.c
  group common/utils/unit_test
    ../../../../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../../utils/stdio/: write.c read.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: exceptions.c system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/ebi/smc
    ../../../../../../../../../sam/drivers/ebi/smc/: smc.c
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/matrix
    ../../../../../../../../../sam/drivers/matrix/: matrix.c
  group sam/boards/sam4s_ek
    ../../../../../../../../../sam/boards/sam4s_ek/: init.c
