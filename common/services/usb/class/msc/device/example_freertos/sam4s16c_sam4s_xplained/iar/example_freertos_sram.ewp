# IAR project example_freertos_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: FREERTOS_USED; ACCESS_USB_ENABLED; UDD_ENABLE; __SAM4S16C__; VIRTUAL_MEMORY_ENABLE; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../..; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../../../sam/drivers/ebi/smc; ../../../../../../../../components/memory/virtual_mem; ..; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam; ../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/drivers/udp; ../../../../../../../gpio; ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../..; ../../../../../../../../../sam/boards/sam4s_xplained; ../../../../../../../storage/ctrl_access; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: example_freertos_sram.bin
  ILINK.IlinkOutputFile: example_freertos_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x4000
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/usb
    ../../../../../../: usb_atmel.h usb_protocol.h
  group common/services/usb/class/msc
    ../../../../: spc_protocol.h usb_protocol_msc.h sbc_protocol.h
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c udi_msc.h udi_msc_conf.h
  group common/services/usb/class/msc/device/example_freertos
    ../../: memories_initialization_sam.c exceptions_sam.c main.c conf_usb.h main.h ui.h
  group common/services/usb/class/msc/device/example_freertos/sam4s16c_sam4s_xplained
    ../: ui.c conf_virtual_mem.h conf_clock.h conf_board.h conf_sleepmgr.h conf_access.h FreeRTOSConfig.h
  group common/services/usb/class/msc/device/example_freertos/sam4s16c_sam4s_xplained/iar
    ./: asf.h
  group common/services/usb/udc
    ../../../../../../udc/: udc.c udi.h udc_desc.h udc.h udd.h
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/sleepmgr
    ../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../clock/: genclk.h pll.h osc.h sysclk.h
  group common/services/clock/sam4s
    ../../../../../../../clock/sam4s/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/gpio
    ../../../../../../../gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../ioport/sam/: ioport_pio.h
  group common/utils
    ../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c virtual_mem.h
  group common/boards
    ../../../../../../../../boards/: board.h
  group sam/utils
    ../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/utils/cmsis/sam4s/include
    ../../../../../../../../../sam/utils/cmsis/sam4s/include/: sam4s2a.h sam4s2c.h sam4sa16b.h system_sam4s.h sam4s.h sam4sa16c.h sam4sd32b.h sam4s4c.h sam4s8c.h sam4s2b.h sam4sd16b.h sam4s4a.h sam4sd32c.h sam4s8b.h sam4s4b.h sam4s16b.h sam4sd16c.h sam4s16c.h
  group sam/utils/cmsis/sam4s/include/instance
    ../../../../../../../../../sam/utils/cmsis/sam4s/include/instance/: instance_uart1.h instance_supc.h instance_efc1.h instance_dacc.h instance_acc.h instance_pmc.h instance_chipid.h instance_rstc.h instance_twi0.h instance_matrix.h instance_uart0.h instance_efc0.h instance_pioa.h instance_udp.h instance_hsmci.h instance_gpbr.h instance_pioc.h instance_rtc.h instance_piob.h instance_tc0.h instance_crccu.h instance_ssc.h instance_usart0.h instance_adc.h instance_usart1.h instance_spi.h instance_wdt.h instance_smc.h instance_twi1.h instance_tc1.h instance_cmcc.h instance_pwm.h instance_rtt.h
  group sam/utils/cmsis/sam4s/include/component
    ../../../../../../../../../sam/utils/cmsis/sam4s/include/component/: component_acc.h component_hsmci.h component_ssc.h component_uart.h component_pmc.h component_cmcc.h component_adc.h component_tc.h component_supc.h component_crccu.h component_chipid.h component_rstc.h component_twi.h component_pwm.h component_pdc.h component_usart.h component_pio.h component_dacc.h component_wdt.h component_gpbr.h component_rtt.h component_udp.h component_matrix.h component_spi.h component_smc.h component_rtc.h component_efc.h
  group sam/utils/cmsis/sam4s/include/pio
    ../../../../../../../../../sam/utils/cmsis/sam4s/include/pio/: pio_sam4sd16c.h pio_sam4s16b.h pio_sam4sa16c.h pio_sam4sd32b.h pio_sam4s4c.h pio_sam4s4a.h pio_sam4s16c.h pio_sam4sa16b.h pio_sam4s2a.h pio_sam4s2c.h pio_sam4s8c.h pio_sam4s4b.h pio_sam4sd32c.h pio_sam4sd16b.h pio_sam4s2b.h pio_sam4s8b.h
  group sam/utils/preprocessor
    ../../../../../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/header_files
    ../../../../../../../../../sam/utils/header_files/: io.h
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c pio_handler.h pio.h
  group sam/drivers/ebi/smc
    ../../../../../../../../../sam/drivers/ebi/smc/: smc.c smc.h
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/boards/sam4s_xplained
    ../../../../../../../../../sam/boards/sam4s_xplained/: init.c led.c led.h sam4s_xplained.h
  group thirdparty/freertos/freertos-7.0.0/source
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/: queue.c list.c tasks.c croutine.c timers.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/memmang
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/portable/iar/sam/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.0.0/source/include
    ../../../../../../../../../thirdparty/freertos/freertos-7.0.0/source/include/: mpu_wrappers.h task.h list.h semphr.h croutine.h queue.h timers.h StackMacros.h projdefs.h FreeRTOS.h portable.h
