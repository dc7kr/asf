# IAR project example_freertos.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1100; UDD_ENABLE; ACCESS_USB_ENABLED; FREERTOS_USED; VIRTUAL_MEMORY_ENABLE; CONFIG_INTERRUPT_FORCE_INTC; SD_MMC_SPI_ENABLE; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../..; ..; ../../../../../../../../../avr32/components/memory/sd_mmc/sd_mmc_spi; ../../../../../../../../components/memory/data_flash/at45dbx; ../../../../../../../../../avr32/boards; ../../../../../../../spi/uc3_spi; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../components/memory/virtual_mem; ../../../../../../../../../avr32/drivers/tc; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/boards/evk1100; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../avr32/drivers/spi; ../../../../../../../../../thirdparty/freertos/source/include; ../../..; ../../../../../../../clock; ../../../../../../udc; ../../../../../..; ../../../../../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3; ../../../../../../../spi; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/usart; ../../../../../../../../../avr32/drivers/flashc; ../../../..; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../../avr32/drivers/intc; ../../../../../../../storage/ctrl_access; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb/class/msc/device
    ../../../: udi_msc_desc.c udi_msc.c
  group common/services/usb/class/msc/device/example_freertos
    ../../: memories_initialization_uc3.c main.c
  group common/services/usb/class/msc/device/example_freertos/at32uc3a0512_evk1100
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/storage/ctrl_access
    ../../../../../../../storage/ctrl_access/: ctrl_access.c
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3a0_a1
    ../../../../../../../clock/uc3a0_a1/: sysclk.c
  group common/services/spi/uc3_spi
    ../../../../../../../spi/uc3_spi/: spi_master.c
  group common/components/memory/data_flash/at45dbx
    ../../../../../../../../components/memory/data_flash/at45dbx/: at45dbx.c at45dbx_mem.c
  group common/components/memory/virtual_mem
    ../../../../../../../../components/memory/virtual_mem/: virtual_mem.c
  group avr32/boards/evk1100
    ../../../../../../../../../avr32/boards/evk1100/: led.c init.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi
    ../../../../../../../../../avr32/components/memory/sd_mmc/sd_mmc_spi/: sd_mmc_spi_mem.c sd_mmc_spi.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/usart
    ../../../../../../../../../avr32/drivers/usart/: usart.c
  group avr32/drivers/tc
    ../../../../../../../../../avr32/drivers/tc/: tc.c
  group avr32/drivers/intc
    ../../../../../../../../../avr32/drivers/intc/: intc.c
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group thirdparty/freertos/source
    ../../../../../../../../../thirdparty/freertos/source/: tasks.c queue.c list.c timers.c croutine.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3/: write.c read.c port.c exception.s82
  group thirdparty/freertos/source/portable/memmang
    ../../../../../../../../../thirdparty/freertos/source/portable/memmang/: heap_3.c
