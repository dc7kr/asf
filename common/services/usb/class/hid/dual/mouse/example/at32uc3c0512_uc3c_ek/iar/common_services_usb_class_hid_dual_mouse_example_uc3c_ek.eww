<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_hid_dual_mouse_example_uc3c_ek.ewp</path>
	</project>
</workspace>
