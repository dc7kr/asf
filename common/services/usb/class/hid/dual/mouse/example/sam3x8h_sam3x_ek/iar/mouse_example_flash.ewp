# IAR project mouse_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; __SAM3X8H__; ARM_MATH_CM3=true; BOARD=SAM3X_EK; UDD_ENABLE
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/drivers/uotghs; ../../../../../host/mouse; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/boards/sam3x_ek; ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../../../../../sam/utils/cmsis/sam3x/include; ../..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../device/mouse; ../../../../../../../uhc; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../gpio; ..; ../../../../../../../../../../sam/drivers/uart; ../../../../../../../../../../sam/utils; ../../../../../device; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_example_flash.bin
  ILINK.IlinkOutputFile: mouse_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/usb/class/hid/device
    ../../../../../device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c
  group common/services/usb/class/hid/host/mouse
    ../../../../../host/mouse/: uhi_hid_mouse.c
  group common/services/usb/class/hid/dual/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/dual/mouse/example/sam3x8h_sam3x_ek
    ../: ui.c
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam3x
    ../../../../../../../../clock/sam3x/: sysclk.c
  group sam/drivers/uotghs
    ../../../../../../../../../../sam/drivers/uotghs/: uotghs_host.c uotghs_device.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam3x_ek
    ../../../../../../../../../../sam/boards/sam3x_ek/: init.c led.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
