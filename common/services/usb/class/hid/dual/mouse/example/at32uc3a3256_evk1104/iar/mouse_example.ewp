# IAR project mouse_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=EVK1104; UDD_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ..; ../../../../../host/mouse; ../../../../../../../../../../avr32/components/joystick/skrhabe010; ../../../../../../../../../../avr32/boards; ../../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../../avr32/drivers/eic; ../../../../../../../../../../avr32/boards/evk1104; ../../../../../../../../clock; ../../../../../../../../../../avr32/utils; ../../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../device/mouse; ../../../../../../../uhc; ../..; ../../../../../../../udc; ../../../../../../..; ../../../../../device; ../../../../../../../../../boards; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=EVK1104; UDD_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c
  group common/services/usb/class/hid/device
    ../../../../../device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c
  group common/services/usb/class/hid/dual/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/dual/mouse/example/at32uc3a3256_evk1104
    ../: ui.c
  group common/services/usb/class/hid/host/mouse
    ../../../../../host/mouse/: uhi_hid_mouse.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/sleepmgr/uc3
    ../../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3a3_a4
    ../../../../../../../../clock/uc3a3_a4/: sysclk.c
  group avr32/drivers/usbb
    ../../../../../../../../../../avr32/drivers/usbb/: usbb_device.c usbb_host.c
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/eic
    ../../../../../../../../../../avr32/drivers/eic/: eic.c
  group avr32/drivers/gpio
    ../../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/evk1104
    ../../../../../../../../../../avr32/boards/evk1104/: init.c led.c
  group avr32/utils/startup
    ../../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
