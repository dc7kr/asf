# IAR project mouse_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4LC4C Atmel ATSAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; __SAM4LC4C__; BOARD=SAM4L_EK; UDD_ENABLE; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ../../../../../host/mouse; ../../../../../../../../../../sam/drivers/usbc; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../..; ../../../../../../../../../../sam/drivers/eic; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/boards/sam4l_ek; ../../../../../../../../../../sam/drivers/wdt; ../../../../../device/mouse; ../../../../../../../uhc; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/gpio; ../../../../../../../../delay; ../../../../../../../../../../sam/utils; ../../../../../device; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../..; ../../../../../../../../../../sam/drivers/bpm; ..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: mouse_example_flash.bin
  ILINK.IlinkOutputFile: mouse_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_heap__=0x200
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils
    ../../../../../../../../../utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/usb
    ../../../../../../../: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c udd.h udc.h udc_desc.h udi.h
  group common/services/usb/class/hid
    ../../../../../: usb_protocol_hid.h
  group common/services/usb/class/hid/device
    ../../../../../device/: udi_hid.c udi_hid.h
  group common/services/usb/class/hid/device/mouse
    ../../../../../device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c udi_hid_mouse_conf.h udi_hid_mouse.h
  group common/services/usb/class/hid/host/mouse
    ../../../../../host/mouse/: uhi_hid_mouse.c uhi_hid_mouse.h
  group common/services/usb/class/hid/dual/mouse/example
    ../../: main.c conf_usb_host.h conf_usb.h ui.h main.h
  group common/services/usb/class/hid/dual/mouse/example/sam4lc4c_sam4l_ek
    ../: ui.c conf_clock.h conf_board.h conf_sleepmgr.h
  group common/services/usb/class/hid/dual/mouse/example/sam4lc4c_sam4l_ek/iar
    ./: asf.h
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c uhd.h uhc.h uhi.h
  group common/services/clock
    ../../../../../../../../clock/: dfll.h pll.h sysclk.h genclk.h osc.h
  group common/services/clock/sam4l
    ../../../../../../../../clock/sam4l/: sysclk.c pll.c osc.c dfll.c pll.h sysclk.h genclk.h osc.h dfll.h
  group common/services/delay
    ../../../../../../../../delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../../../sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam4l
    ../../../../../../../../sleepmgr/sam4l/: sleepmgr.c sleepmgr.h
  group common/services/ioport
    ../../../../../../../../ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../ioport/sam/: ioport_gpio.h
  group common/boards
    ../../../../../../../../../boards/: board.h
  group sam/drivers/gpio
    ../../../../../../../../../../sam/drivers/gpio/: gpio.c gpio.h
  group sam/drivers/usbc
    ../../../../../../../../../../sam/drivers/usbc/: usbc_host.c usbc_device.c usbc_otg.h usbc_device.h usbc_host.h
  group sam/drivers/flashcalw
    ../../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c flashcalw.h
  group sam/drivers/eic
    ../../../../../../../../../../sam/drivers/eic/: eic.c eic.h
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/wdt
    ../../../../../../../../../../sam/drivers/wdt/: wdt_sam4l.c wdt_sam4l.h
  group sam/drivers/bpm
    ../../../../../../../../../../sam/drivers/bpm/: bpm.c bpm.h
  group sam/utils
    ../../../../../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c system_sam4l.c system_sam4l.h exceptions.h
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/utils/cmsis/sam4l/include
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/: sam4lc8a.h sam4lc4a.h sam4ls4b.h sam4lc8c.h sam4l.h sam4ls4a.h sam4lc2c.h sam4lc2a.h sam4lc8b.h sam4ls2a.h sam4ls2c.h sam4ls8c.h sam4ls8a.h sam4lc2b.h sam4lc4c.h sam4ls2b.h sam4ls8b.h sam4ls4c.h sam4lc4b.h
  group sam/utils/cmsis/sam4l/include/instance
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/instance/: instance_usart3.h instance_catb.h instance_tc0.h instance_smap.h instance_acifc.h instance_hcache.h instance_pm.h instance_scif.h instance_parc.h instance_tc1.h instance_freqm.h instance_pevc.h instance_adcife.h instance_gloc.h instance_wdt.h instance_twim2.h instance_twis0.h instance_bpm.h instance_aesa.h instance_gpio.h instance_trng.h instance_dacc.h instance_chipid.h instance_iisc.h instance_twim0.h instance_eic.h instance_crccu.h instance_usbc.h instance_twim3.h instance_hmatrix.h instance_ast.h instance_picouart.h instance_usart0.h instance_twim1.h instance_twis1.h instance_usart2.h instance_abdacb.h instance_lcdca.h instance_bscif.h instance_spi.h instance_pdca.h instance_hflashc.h instance_usart1.h
  group sam/utils/cmsis/sam4l/include/component
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/component/: component_eic.h component_trng.h component_abdacb.h component_freqm.h component_hcache.h component_pdca.h component_bscif.h component_pm.h component_aesa.h component_twis.h component_catb.h component_picouart.h component_hmatrixb.h component_smap.h component_scif.h component_gloc.h component_lcdca.h component_crccu.h component_twim.h component_dacc.h component_adcife.h component_pevc.h component_spi.h component_iisc.h component_usart.h component_usbc.h component_gpio.h component_parc.h component_wdt.h component_bpm.h component_ast.h component_tc.h component_flashcalw.h component_acifc.h component_chipid.h
  group sam/utils/cmsis/sam4l/include/pio
    ../../../../../../../../../../sam/utils/cmsis/sam4l/include/pio/: pio_sam4ls2b.h pio_sam4ls8b.h pio_sam4lc2b.h pio_sam4ls8c.h pio_sam4lc4b.h pio_sam4lc8c.h pio_sam4lc8a.h pio_sam4ls8a.h pio_sam4lc4a.h pio_sam4ls4a.h pio_sam4lc8b.h pio_sam4ls4b.h pio_sam4ls2a.h pio_sam4ls2c.h pio_sam4lc4c.h pio_sam4lc2a.h pio_sam4ls4c.h pio_sam4lc2c.h
  group sam/utils/preprocessor
    ../../../../../../../../../../sam/utils/preprocessor/: stringz.h tpaste.h mrepeat.h preprocessor.h
  group sam/utils/header_files
    ../../../../../../../../../../sam/utils/header_files/: io.h
  group sam/boards/sam4l_ek
    ../../../../../../../../../../sam/boards/sam4l_ek/: board_monitor.c init.c sam4l_ek.h board_monitor.h led.h
