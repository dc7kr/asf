# IAR project common_services_usb_class_hid_dual_mouse_example_uc3c_ek.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=UC3C_EK; UDD_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../host/mouse; ../../../../../../../../../../avr32/drivers/scif; ..; ../../../../../../../../../../avr32/boards; ../../../../../../../../../../avr32/drivers/usbc; ../../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../../avr32/drivers/eic; ../../../../../../../../../../avr32/boards/uc3c_ek; ../../../../../../../../clock; ../../../../../../../../../../avr32/utils; ../../../../../../../../../../avr32/drivers/gpio; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../device/mouse; ../../../../../../../uhc; ../..; ../../../../../../../udc; ../../../../../../..; ../../../../../device; ../../../../../../../../../boards; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=UC3C_EK; UDD_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../avr32/utils/linker_scripts/at32uc3c/0512c/iar/lnkuc3c0512c.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_uc3c.c power_clocks_lib.c
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/scif
    ../../../../../../../../../../avr32/drivers/scif/: scif_uc3c.c
  group avr32/drivers/usbc
    ../../../../../../../../../../avr32/drivers/usbc/: usbc_device.c usbc_host.c
  group avr32/drivers/eic
    ../../../../../../../../../../avr32/drivers/eic/: eic.c
  group avr32/drivers/gpio
    ../../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/uc3c_ek
    ../../../../../../../../../../avr32/boards/uc3c_ek/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/usb/class/hid/device
    ../../../../../device/: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../../../device/mouse/: udi_hid_mouse.c udi_hid_mouse_desc.c
  group common/services/usb/class/hid/host/mouse
    ../../../../../host/mouse/: uhi_hid_mouse.c
  group common/services/usb/class/hid/dual/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/dual/mouse/example/at32uc3c0512_uc3c_ek
    ../: ui.c
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c
  group common/services/clock/uc3c
    ../../../../../../../../clock/uc3c/: pll.c sysclk.c osc.c
  group common/services/sleepmgr/uc3
    ../../../../../../../../sleepmgr/uc3/: sleepmgr.c
