# IAR project common_services_usb_class_hid_host_mouse_example_evk1101.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=EVK1101
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../uhc; ../../..; ../../../../../../../../clock; ../../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../boards; ../../../../../../../../../../avr32/boards; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../../avr32/drivers/pm; ../../../../../../..; ../../../../../../../../../../avr32/utils; ../../../../../../../../../../avr32/boards/evk1101; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../..; ..; ../../../../../../../../../../avr32/drivers/gpio; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=EVK1101
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../avr32/utils/linker_scripts/at32uc3b/0256/iar/lnkuc3b0256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb/uhc
    ../../../../../../../uhc/: uhc.c
  group common/services/usb/class/hid/host/mouse
    ../../../: uhi_hid_mouse.c
  group common/services/usb/class/hid/host/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/host/mouse/example/at32uc3b0256_evk1101
    ../: ui.c
  group common/services/sleepmgr/uc3
    ../../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3b0_b1
    ../../../../../../../../clock/uc3b0_b1/: sysclk.c
  group avr32/boards/evk1101
    ../../../../../../../../../../avr32/boards/evk1101/: init.c led.c
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/usbb
    ../../../../../../../../../../avr32/drivers/usbb/: usbb_host.c
  group avr32/drivers/gpio
    ../../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/utils/startup
    ../../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
