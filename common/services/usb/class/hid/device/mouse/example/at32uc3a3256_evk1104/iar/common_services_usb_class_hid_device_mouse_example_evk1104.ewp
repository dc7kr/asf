# IAR project common_services_usb_class_hid_device_mouse_example_evk1104.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=EVK1104; UDD_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../..; ../../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../../avr32/drivers/gpio; ../../../..; ../../../../../../../../clock; ../../../../../../../../../../avr32/boards; ../../../../..; ../../../../../../../../../boards; ..; ../..; ../../../../../../../../../../avr32/drivers/flashc; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../avr32/utils; ../../../../../../../../../../avr32/boards/evk1104; ../../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../avr32/drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=EVK1104; UDD_ENABLE
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../../avr32/utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/mouse
    ../../../: udi_hid_mouse_desc.c udi_hid_mouse.c
  group common/services/usb/class/hid/device/mouse/example
    ../../: main.c
  group common/services/usb/class/hid/device/mouse/example/at32uc3a3256_evk1104
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/sleepmgr/uc3
    ../../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3a3_a4
    ../../../../../../../../clock/uc3a3_a4/: sysclk.c
  group avr32/drivers/usbb
    ../../../../../../../../../../avr32/drivers/usbb/: usbb_device.c
  group avr32/drivers/flashc
    ../../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/pm
    ../../../../../../../../../../avr32/drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/eic
    ../../../../../../../../../../avr32/drivers/eic/: eic.c
  group avr32/drivers/gpio
    ../../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/boards/evk1104
    ../../../../../../../../../../avr32/boards/evk1104/: led.c init.c
  group avr32/utils/startup
    ../../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
