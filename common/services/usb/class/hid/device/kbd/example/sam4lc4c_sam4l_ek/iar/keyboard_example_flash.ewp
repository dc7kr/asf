# IAR project keyboard_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4LC4C Atmel SAM4LC4C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4L_EK; UDD_ENABLE; ARM_MATH_CM4=true; __ATSAM4LC4C__
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/drivers/usbc; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/utils/cmsis/sam4l/include; ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates; ../../../../../../../../../../sam/drivers/eic; ../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../boards; ../../../../../../../../../../sam/boards/sam4l_ek; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../utils; ..; ../../../../../../../../../../sam/utils; ../../../..; ../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../../sam/drivers/flashcalw; ../../../../../../../../ioport; ../../../../..; ../../../../../../../../../../sam/drivers/bpm; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: keyboard_example_flash.bin
  ILINK.IlinkOutputFile: keyboard_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam4l/sam4l4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/kbd
    ../../../: udi_hid_kbd.c udi_hid_kbd_desc.c
  group common/services/usb/class/hid/device/kbd/example
    ../../: main.c
  group common/services/usb/class/hid/device/kbd/example/sam4lc4c_sam4l_ek
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/clock/sam4l
    ../../../../../../../../clock/sam4l/: osc.c sysclk.c pll.c dfll.c
  group common/services/sleepmgr/sam4l
    ../../../../../../../../sleepmgr/sam4l/: sleepmgr.c
  group sam/utils/cmsis/sam4l/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/: exceptions.c
  group sam/utils/cmsis/sam4l/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam4l/source/templates/iar/: startup_sam4l.c
  group sam/drivers/usbc
    ../../../../../../../../../../sam/drivers/usbc/: usbc_device.c
  group sam/drivers/eic
    ../../../../../../../../../../sam/drivers/eic/: eic.c
  group sam/drivers/flashcalw
    ../../../../../../../../../../sam/drivers/flashcalw/: flashcalw.c
  group sam/drivers/bpm
    ../../../../../../../../../../sam/drivers/bpm/: bpm.c
  group sam/boards/sam4l_ek
    ../../../../../../../../../../sam/boards/sam4l_ek/: init.c
