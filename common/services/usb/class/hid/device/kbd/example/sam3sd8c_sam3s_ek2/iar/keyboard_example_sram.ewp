# IAR project keyboard_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/preprocessor; ..; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../../../sam/boards/sam3s_ek2; ../../../../../../../../gpio; ../../../../../../../../../../sam/utils; ../../../..; ../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../../../../../../../sam/utils/cmsis/sam3s8/include; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3S_EK2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: keyboard_example_sram.bin
  ILINK.IlinkOutputFile: keyboard_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/kbd
    ../../../: udi_hid_kbd.c udi_hid_kbd_desc.c
  group common/services/usb/class/hid/device/kbd/example
    ../../: main.c
  group common/services/usb/class/hid/device/kbd/example/sam3sd8c_sam3s_ek2
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam3s
    ../../../../../../../../clock/sam3s/: sysclk.c
  group sam/boards/sam3s_ek2
    ../../../../../../../../../../sam/boards/sam3s_ek2/: init.c led.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
