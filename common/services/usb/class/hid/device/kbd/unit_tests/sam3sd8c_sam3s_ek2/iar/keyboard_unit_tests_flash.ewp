# IAR project keyboard_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAM3S_EK2; _ASSERT_ENABLE_; __SAM3SD8C__; UDD_ENABLE; ARM_MATH_CM3=true; TEST_SUITE_DEFINE_ASSERT_MACRO
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../serial; ../../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ..; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../../../sam/boards/sam3s_ek2; ../../../../../../../../gpio; ../../../../../../../../../../sam/drivers/uart; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../serial/sam_uart; ../../../../../../../../../boards; ../..; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../../../../../../../sam/utils/cmsis/sam3s8/include; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: keyboard_unit_tests_flash.bin
  ILINK.IlinkOutputFile: keyboard_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/kbd
    ../../../: udi_hid_kbd.c udi_hid_kbd_desc.c
  group common/services/usb/class/hid/device/kbd/unit_tests
    ../../: unit_tests.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam3s
    ../../../../../../../../clock/sam3s/: sysclk.c
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam3s_ek2
    ../../../../../../../../../../sam/boards/sam3s_ek2/: led.c init.c
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
