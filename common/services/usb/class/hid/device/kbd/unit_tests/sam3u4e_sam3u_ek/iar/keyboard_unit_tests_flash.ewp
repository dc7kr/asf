# IAR project keyboard_unit_tests_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: _ASSERT_ENABLE_; UDD_ENABLE; ARM_MATH_CM3=true; __SAM3U4E__; TEST_SUITE_DEFINE_ASSERT_MACRO; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../../../../../../../serial; ../../../../../../../../ioport; ..; ../../..; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../utils/stdio/stdio_serial; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../../../../sam/drivers/udphs; ../../../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../udc; ../../../../../../..; ../../../../../../../../gpio; ../../../../../../../../../../sam/drivers/uart; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/drivers/usart; ../../../../../../../../serial/sam_uart; ../../../../../../../../../boards; ../..; ../../../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: keyboard_unit_tests_flash.bin
  ILINK.IlinkOutputFile: keyboard_unit_tests_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/utils/unit_test
    ../../../../../../../../../utils/unit_test/: suite.c
  group common/utils/stdio
    ../../../../../../../../../utils/stdio/: read.c write.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/kbd
    ../../../: udi_hid_kbd.c udi_hid_kbd_desc.c
  group common/services/usb/class/hid/device/kbd/unit_tests
    ../../: unit_tests.c
  group common/services/clock/sam3u
    ../../../../../../../../clock/sam3u/: sysclk.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/serial
    ../../../../../../../../serial/: usart_serial.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/drivers/usart
    ../../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/udphs
    ../../../../../../../../../../sam/drivers/udphs/: udphs_device.c
  group sam/drivers/uart
    ../../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam3u_ek
    ../../../../../../../../../../sam/boards/sam3u_ek/: init.c led.c
