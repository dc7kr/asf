# IAR project generic_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK; ARM_MATH_CM3=true; UDD_ENABLE
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../..; ../../../../../../../../../../sam/utils/cmsis/sam3s/include; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../../../sam/utils/cmsis/sam3s/source/templates; ../../../../../../../../../../sam/boards/sam3s_ek; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../..; ../../../../../../../../../../sam/drivers/udp; ../../../../../../../../gpio; ../../../../../../../../../../sam/utils; ../../../..; ..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../..; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK; ARM_MATH_CM3=true; UDD_ENABLE
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_sram.bin
  ILINK.IlinkOutputFile: generic_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c
  group common/services/usb/class/hid/device/generic/example/sam3s4c_sam3s_ek
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam3s
    ../../../../../../../../clock/sam3s/: sysclk.c
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3s/source/templates/: exceptions.c system_sam3s.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/drivers/udp
    ../../../../../../../../../../sam/drivers/udp/: udp_device.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/boards/sam3s_ek
    ../../../../../../../../../../sam/boards/sam3s_ek/: led.c init.c
