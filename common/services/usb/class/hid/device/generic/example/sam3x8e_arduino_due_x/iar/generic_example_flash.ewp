# IAR project generic_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../../../../../../../sam/drivers/uotghs; ../../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../../sam/drivers/pmc; ../../..; ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ..; ../../../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../../../sleepmgr; ../../../../../../../../../utils; ../../../../../../../../clock; ../../../../../../../../../../sam/boards; ../../../../../../../udc; ../..; ../../../../../../../../gpio; ../../../../../../../../../../sam/utils; ../../../..; ../../../../../../../../../../sam/utils/header_files; ../../../../../../../../../boards; ../../../../../../..; ../../../../../../../../ioport; ../../../../../../../../../../sam/drivers/pio; ../../../../..; ../../../../../../../../../../sam/boards/arduino_due_x; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: generic_example_flash.bin
  ILINK.IlinkOutputFile: generic_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/utils/interrupt
    ../../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group common/services/usb/udc
    ../../../../../../../udc/: udc.c
  group common/services/usb/class/hid/device
    ../../../../: udi_hid.c
  group common/services/usb/class/hid/device/generic
    ../../../: udi_hid_generic.c udi_hid_generic_desc.c
  group common/services/usb/class/hid/device/generic/example
    ../../: main.c
  group common/services/usb/class/hid/device/generic/example/sam3x8e_arduino_due_x
    ../: ui.c
  group common/services/clock/sam3x
    ../../../../../../../../clock/sam3x/: sysclk.c
  group common/services/sleepmgr/sam
    ../../../../../../../../sleepmgr/sam/: sleepmgr.c
  group sam/drivers/uotghs
    ../../../../../../../../../../sam/drivers/uotghs/: uotghs_device.c
  group sam/drivers/pmc
    ../../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/pio
    ../../../../../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/boards/arduino_due_x
    ../../../../../../../../../../sam/boards/arduino_due_x/: init.c led.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
