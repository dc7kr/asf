# IAR project device_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../../..; ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pmc; ..; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../..; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/drivers/udphs; ../../../../../../../../../sam/boards/sam3u_ek; ../../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../..; ../..; ../../../../../../../gpio; ../../../../../../../../../sam/utils; ../../../../../../udc; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; ARM_MATH_CM3=true; UDD_ENABLE; BOARD=SAM3U_EK
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_example_flash.bin
  ILINK.IlinkOutputFile: device_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group common/services/usb/class/cdc/device
    ../../../: udi_cdc.c udi_cdc_desc.c
  group common/services/usb/class/cdc/device/example
    ../../: uart_sam.c main.c
  group common/services/usb/class/cdc/device/example/sam3u4e_sam3u_ek
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/clock/sam3u
    ../../../../../../../clock/sam3u/: sysclk.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group sam/boards/sam3u_ek
    ../../../../../../../../../sam/boards/sam3u_ek/: led.c init.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/udphs
    ../../../../../../../../../sam/drivers/udphs/: udphs_device.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: exceptions.c system_sam3u.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
