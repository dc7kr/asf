<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_cdc_device_example_uc3b_board_controller.ewp</path>
	</project>
</workspace>
