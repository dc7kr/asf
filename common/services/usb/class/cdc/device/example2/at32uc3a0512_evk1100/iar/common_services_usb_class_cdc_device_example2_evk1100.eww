<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_cdc_device_example2_evk1100.ewp</path>
	</project>
</workspace>
