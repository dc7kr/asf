# IAR project host_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: UHD_ENABLE; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/drivers/uotghs; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../../sam/boards/sam3x_ek; ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../..; ../../../../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../..; ../../../../../../uhc; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../..; ..; ../../../../../../../gpio; ../../../../../../../../../sam/drivers/uart; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/drivers/usart; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../ioport; ../../../../../../../../../sam/drivers/pmc; ../..; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: UHD_ENABLE; ARM_MATH_CM3=true; BOARD=SAM3X_EK; __SAM3X8H__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: host_example_sram.bin
  ILINK.IlinkOutputFile: host_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c sleep.c
  group sam/drivers/uart
    ../../../../../../../../../sam/drivers/uart/: uart.c
  group sam/drivers/usart
    ../../../../../../../../../sam/drivers/usart/: usart.c
  group sam/drivers/uotghs
    ../../../../../../../../../sam/drivers/uotghs/: uotghs_host.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/: system_sam3x.c exceptions.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/sam3x_ek
    ../../../../../../../../../sam/boards/sam3x_ek/: init.c led.c
  group common/services/usb/class/cdc/host
    ../../../: uhi_cdc.c
  group common/services/usb/class/cdc/host/example
    ../../: uart_sam.c main.c
  group common/services/usb/class/cdc/host/example/sam3x8h_sam3x_ek
    ../: ui.c
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c
  group common/services/clock/sam3x
    ../../../../../../../clock/sam3x/: sysclk.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
