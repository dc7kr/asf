# IAR project host_example.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: UHD_ENABLE; BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../../../../../avr32/drivers/rtc; ../../../..; ..; ../../../../../../../../../avr32/boards; ../../../../../../../../../avr32/drivers/usbb; ../../../../../../../../../avr32/drivers/pm; ../../../../../../../../../avr32/drivers/eic; ../../../../../../../../../avr32/components/display/et024006dhu; ../..; ../../../../../../../../../avr32/boards/evk1105; ../../../../../../../../../avr32/utils; ../../../../../../../../../avr32/drivers/gpio; ../../../../../../../sleepmgr; ../../../../../../../../utils; ../../../../../../../../../avr32/drivers/spi; ../../../../../../uhc; ../../../../../../../clock; ../../../../../../../../../avr32/drivers/pwm; ../../../../../..; ../../../../../../../../../avr32/drivers/cpu/cycle_counter; ../../..; ../../../../../../../../../avr32/drivers/ebi/smc; ../../../../../../../../boards; ../../../../../../../../../avr32/drivers/flashc; ../../../../../../../../../avr32/services/delay; ../../../../../../../../../avr32/utils/preprocessor; ../../../../../../../../../avr32/drivers/intc; ../../../../../../../../../avr32/components/touch/qt1081; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: UHD_ENABLE; BOARD=EVK1105; CONFIG_INTERRUPT_FORCE_INTC
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../../../../avr32/utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/flashc
    ../../../../../../../../../avr32/drivers/flashc/: flashc.c
  group avr32/drivers/eic
    ../../../../../../../../../avr32/drivers/eic/: eic.c
  group avr32/drivers/gpio
    ../../../../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/drivers/pm
    ../../../../../../../../../avr32/drivers/pm/: power_clocks_lib.c pm.c pm_conf_clocks.c
  group avr32/drivers/spi
    ../../../../../../../../../avr32/drivers/spi/: spi.c
  group avr32/drivers/usbb
    ../../../../../../../../../avr32/drivers/usbb/: usbb_host.c
  group avr32/drivers/ebi/smc
    ../../../../../../../../../avr32/drivers/ebi/smc/: smc.c
  group avr32/drivers/intc
    ../../../../../../../../../avr32/drivers/intc/: intc.c exception.s82
  group avr32/drivers/rtc
    ../../../../../../../../../avr32/drivers/rtc/: rtc.c
  group avr32/drivers/pwm
    ../../../../../../../../../avr32/drivers/pwm/: pwm.c
  group avr32/boards/evk1105
    ../../../../../../../../../avr32/boards/evk1105/: init.c led.c
  group avr32/services/delay
    ../../../../../../../../../avr32/services/delay/: delay.c
  group avr32/components/display/et024006dhu
    ../../../../../../../../../avr32/components/display/et024006dhu/: et024006dhu.c
  group avr32/utils/startup
    ../../../../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/usb/class/aoa/host
    ../../../: uhi_aoa.c
  group common/services/usb/class/aoa/host/example
    ../../: main.c
  group common/services/usb/class/aoa/host/example/at32uc3a0512_evk1105
    ../: usb_connector.c ui.c cellphone.c
  group common/services/usb/uhc
    ../../../../../../uhc/: uhc.c
  group common/services/sleepmgr/uc3
    ../../../../../../../sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3a0_a1
    ../../../../../../../clock/uc3a0_a1/: sysclk.c
