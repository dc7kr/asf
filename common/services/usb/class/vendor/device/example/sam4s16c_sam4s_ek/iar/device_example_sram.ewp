# IAR project device_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM4S_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4S16C__
  ICCARM.CCIncludePath2: ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates; ../..; ../../../../../../../../../sam/boards/sam4s_ek; ../../../..; ../../../../../../../../../sam/utils; ../../../../../../../clock; ../../../../../../../../../sam/boards; ../../../../../../../../../sam/utils/header_files; ../../../../../../../../boards; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../utils; ../../../../../../../../../sam/drivers/udp; ../../..; ../../../../../../../sleepmgr; ..; ../../../../../../../../../sam/utils/cmsis/sam4s/include; ../../../../../../../gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM4S_EK; UDD_ENABLE; ARM_MATH_CM4=true; __SAM4S16C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: device_example_sram.bin
  ILINK.IlinkOutputFile: device_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/sam4s_ek
    ../../../../../../../../../sam/boards/sam4s_ek/: init.c led.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/udp
    ../../../../../../../../../sam/drivers/udp/: udp_device.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/usb/class/vendor/device
    ../../../: udi_vendor.c udi_vendor_desc.c
  group common/services/usb/class/vendor/device/example
    ../../: main.c
  group common/services/usb/class/vendor/device/example/sam4s16c_sam4s_ek
    ../: ui.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/services/clock/sam4s
    ../../../../../../../clock/sam4s/: sysclk.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
