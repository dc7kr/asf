# IAR project device_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3U4 Atmel AT91SAM3U4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3U4E__; UDD_ENABLE; BOARD=SAM3U_EK
  ICCARM.CCIncludePath2: ../..; ../../../../../../../../../sam/drivers/udphs; ../../../..; ../../../../../../../../../sam/utils; ../../../../../../../../../sam/utils/cmsis/sam3u/include; ../../../../../../../clock; ../../../../../../../../../sam/boards; ..; ../../../../../../../../boards; ../../../../../../../../../sam/utils/preprocessor; ../../../../../../../../../sam/boards/sam3u_ek; ../../../../../../udc; ../../../../../..; ../../../../../../../../../sam/drivers/pmc; ../../../../../../../../../sam/drivers/pio; ../../../../../../../../utils; ../../../../../../../sleepmgr; ../../..; ../../../../../../../../../sam/utils/header_files; ../../../../../../../gpio; ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3U4E__; UDD_ENABLE; BOARD=SAM3U_EK
  OBJCOPY.OOCOutputFile: device_example_sram.bin
  ILINK.IlinkOutputFile: device_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../../../../sam/utils/linker_scripts/sam3u/sam3u4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  group sam/drivers/pio
    ../../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/udphs
    ../../../../../../../../../sam/drivers/udphs/: udphs_device.c
  group sam/drivers/pmc
    ../../../../../../../../../sam/drivers/pmc/: pmc.c
  group sam/utils/cmsis/sam3u/source/templates
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/: system_sam3u.c exceptions.c
  group sam/utils/cmsis/sam3u/source/templates/iar
    ../../../../../../../../../sam/utils/cmsis/sam3u/source/templates/iar/: startup_sam3u.c
  group sam/boards/sam3u_ek
    ../../../../../../../../../sam/boards/sam3u_ek/: init.c
  group common/services/clock/sam3u
    ../../../../../../../clock/sam3u/: sysclk.c
  group common/services/usb/class/vendor/device
    ../../../: udi_vendor.c udi_vendor_desc.c
  group common/services/usb/class/vendor/device/example
    ../../: main.c
  group common/services/usb/class/vendor/device/example/sam3u4e_sam3u_ek
    ../: ui.c
  group common/services/usb/udc
    ../../../../../../udc/: udc.c
  group common/services/sleepmgr/sam
    ../../../../../../../sleepmgr/sam/: sleepmgr.c
  group common/utils/interrupt
    ../../../../../../../../utils/interrupt/: interrupt_sam_nvic.c
