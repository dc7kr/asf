<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_usb_class_vendor_device_example_xmega_a3bu_xplained.ewp</path>
	</project>
</workspace>
