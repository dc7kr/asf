<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_uc3-l0_delay-demo.ewp</path>
	</project>
</workspace>
