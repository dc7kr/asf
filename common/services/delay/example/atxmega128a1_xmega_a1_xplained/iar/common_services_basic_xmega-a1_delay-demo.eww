<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_xmega-a1_delay-demo.ewp</path>
	</project>
</workspace>
