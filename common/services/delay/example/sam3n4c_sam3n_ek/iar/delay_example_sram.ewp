# IAR project delay_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../..; ../../../../../../sam/utils; ../../../../clock; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ..; ../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards/sam3n_ek; ../../../../../utils; ../../../../gpio; ../../../../ioport; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; ARM_MATH_CM3=true; __SAM3N4C__
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: delay_example_sram.bin
  ILINK.IlinkOutputFile: delay_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/boards/sam3n_ek
    ../../../../../../sam/boards/sam3n_ek/: init.c led.c
  group common/services/clock/sam3n
    ../../../../clock/sam3n/: sysclk.c
  group common/services/delay/example
    ../../: delay_example.c
  group common/services/delay/sam
    ../../../sam/: cycle_counter.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
