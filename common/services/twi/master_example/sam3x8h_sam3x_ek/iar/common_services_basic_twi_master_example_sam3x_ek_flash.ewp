# IAR project common_services_basic_twi_master_example_sam3x_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3X_EK; __SAM3X8H__
  ICCARM.CCIncludePath2: ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../clock; ../../../../gpio; ../../../../../../sam/utils/header_files; ../../../../../boards; ../..; ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards/sam3x_ek; ../../../../../../sam/boards; ../../..; ..; ../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3X_EK; __SAM3X8H__
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: common_services_basic_twi_master_example_sam3x_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/drivers/twi
    ../../../../../../sam/drivers/twi/: twi.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/utils/syscalls/iar
    ../../../../../../sam/utils/syscalls/iar/: dlib_lowlevel.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/boards/sam3x_ek
    ../../../../../../sam/boards/sam3x_ek/: init.c
  group common/services/twi/master_example
    ../../: twi_master_example.c
  group common/services/clock/sam3x
    ../../../../clock/sam3x/: sysclk.c
