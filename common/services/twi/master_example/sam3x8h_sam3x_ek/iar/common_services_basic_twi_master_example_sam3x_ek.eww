<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_twi_master_example_sam3x_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\common_services_basic_twi_master_example_sam3x_ek_sram.ewp</path>
	</project>
</workspace>
