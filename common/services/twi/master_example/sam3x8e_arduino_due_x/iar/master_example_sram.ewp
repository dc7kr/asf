# IAR project master_example_sram.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../sam/drivers/uart; ../../../../../../sam/boards/arduino_due_x; ../../../../../../sam/utils; ../../../../clock; ../../../../gpio; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ..; ../../../../ioport; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards; ../../../../../utils; ../../..; ../..; ../../../../../../sam/utils/cmsis/sam3x/source/templates; ../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; ARM_MATH_CM3=true; BOARD=ARDUINO_DUE_X
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: master_example_sram.bin
  ILINK.IlinkOutputFile: master_example_sram.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/boards/arduino_due_x
    ../../../../../../sam/boards/arduino_due_x/: led.c init.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: sleep.c pmc.c
  group sam/drivers/twi
    ../../../../../../sam/drivers/twi/: twi.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group common/services/twi/master_example
    ../../: twi_master_example.c
  group common/services/clock/sam3x
    ../../../../clock/sam3x/: sysclk.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
