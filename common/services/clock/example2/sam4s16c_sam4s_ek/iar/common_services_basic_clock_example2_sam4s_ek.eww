<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_sam4s_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_sam4s_ek_sram.ewp</path>
	</project>
</workspace>
