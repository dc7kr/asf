<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_sam3s_ek2_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_sam3s_ek2_sram.ewp</path>
	</project>
</workspace>
