# IAR project common_services_basic_clock_example2_sam3n_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3N4 Atmel SAM3N4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAM3N_EK; __SAM3N4C__
  ICCARM.CCIncludePath2: ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../..; ..; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/cmsis/sam3n/source/templates; ../../../../../../sam/utils/cmsis/sam3n/include; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards; ../../../../../../sam/boards/sam3n_ek; ../../../../gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=SAM3N_EK; __SAM3N4C__
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: common_services_basic_clock_example2_sam3n_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3n/sam3n4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3n/source/templates
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/: exceptions.c system_sam3n.c
  group sam/utils/cmsis/sam3n/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3n/source/templates/iar/: startup_sam3n.c
  group sam/utils/syscalls/iar
    ../../../../../../sam/utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam3n_ek
    ../../../../../../sam/boards/sam3n_ek/: init.c
  group common/services/clock/example2
    ../../: clock_example2_sam.c
  group common/services/clock/sam3n
    ../../../sam3n/: sysclk.c
