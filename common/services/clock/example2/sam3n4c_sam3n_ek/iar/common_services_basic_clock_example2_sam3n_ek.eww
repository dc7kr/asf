<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_sam3n_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example2_sam3n_ek_sram.ewp</path>
	</project>
</workspace>
