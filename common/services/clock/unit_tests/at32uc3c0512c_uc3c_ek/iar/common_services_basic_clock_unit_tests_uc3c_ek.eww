<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_unit_tests_uc3c_ek.ewp</path>
	</project>
</workspace>
