# IAR project clock_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3X8 Atmel SAM3X8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  ICCARM.CCIncludePath2: ../../../../../../sam/drivers/uart; ../../../../../../sam/boards/arduino_due_x; ../../../../../../sam/utils; ../../..; ../../../../../../sam/boards; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/utils/cmsis/sam3x/include; ../../../../../../sam/drivers/pmc; ..; ../../../../../../sam/drivers/pio; ../../../../../utils; ../../../../gpio; ../../../../../../sam/utils/cmsis/sam3x/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3X8E__; BOARD=ARDUINO_DUE_X
  OBJCOPY.OOCOutputFile: clock_example1_flash.bin
  ILINK.IlinkOutputFile: clock_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3x/sam3x8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock/sam3x
    ../../../sam3x/: sysclk.c
  group common/services/clock/example1
    ../../: clock_example1_sam.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/utils/cmsis/sam3x/source/templates
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/: exceptions.c system_sam3x.c
  group sam/utils/cmsis/sam3x/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3x/source/templates/iar/: startup_sam3x.c
  group sam/utils/syscalls/iar
    ../../../../../../sam/utils/syscalls/iar/: dlib_lowlevel.c
  group sam/boards/arduino_due_x
    ../../../../../../sam/boards/arduino_due_x/: init.c
