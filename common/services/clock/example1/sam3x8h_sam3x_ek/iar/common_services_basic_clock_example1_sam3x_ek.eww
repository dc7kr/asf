<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example1_sam3x_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\common_services_basic_clock_example1_sam3x_ek_sram.ewp</path>
	</project>
</workspace>
