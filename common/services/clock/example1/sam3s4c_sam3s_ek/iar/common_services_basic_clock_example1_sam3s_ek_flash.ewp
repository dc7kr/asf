# IAR project common_services_basic_clock_example1_sam3s_ek_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3S4 Atmel SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3S4C__; BOARD=SAM3S_EK
  ICCARM.CCIncludePath2: ../../../../../../sam/utils/header_files; ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../../../../../sam/boards/sam3s_ek; ../../..; ../../../../../../sam/boards; ../../../../../../sam/utils/cmsis/sam3s/include; ../../../../../boards; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ..; ../../../../gpio; ../../../../../../sam/utils/cmsis/sam3s/source/templates; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3S4C__; BOARD=SAM3S_EK
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: common_services_basic_clock_example1_sam3s_ek_flash.elf
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3s/sam3s4/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3s/source/templates
    ../../../../../../sam/utils/cmsis/sam3s/source/templates/: system_sam3s.c exceptions.c
  group sam/utils/cmsis/sam3s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3s/source/templates/iar/: startup_sam3s.c
  group sam/utils/syscalls/iar
    ../../../../../../sam/utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam3s_ek
    ../../../../../../sam/boards/sam3s_ek/: init.c
  group common/services/clock/sam3s
    ../../../sam3s/: sysclk.c
  group common/services/clock/example1
    ../../: clock_example1_sam.c
