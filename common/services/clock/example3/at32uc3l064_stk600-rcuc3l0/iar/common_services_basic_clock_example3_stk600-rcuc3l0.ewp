# IAR project common_services_basic_clock_example3_stk600-rcuc3l0.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=STK600_RCUC3L0
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../delay; ..; ../../../../../../avr32/drivers/gpio; ../../..; ../../../../../boards; ../../../../../../avr32/boards; ../../../../../../avr32/utils; ../../../../../../avr32/drivers/cpu/cycle_counter; ../../../../../../avr32/utils/preprocessor; ../../../../../../avr32/drivers/flashcdw; ../../../../../utils; ../../../../../../avr32/boards/stk600/rcuc3l0; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=STK600_RCUC3L0
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../../avr32/utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/boards/stk600/rcuc3l0
    ../../../../../../avr32/boards/stk600/rcuc3l0/: init.c
  group avr32/drivers/flashcdw
    ../../../../../../avr32/drivers/flashcdw/: flashcdw.c
  group avr32/drivers/gpio
    ../../../../../../avr32/drivers/gpio/: gpio.c
  group avr32/utils/startup
    ../../../../../../avr32/utils/startup/: trampoline_uc3.s82
  group common/services/clock/example3
    ../../: clock_example3_uc3l.c
  group common/services/clock/uc3l
    ../../../uc3l/: osc.c sysclk.c dfll.c
