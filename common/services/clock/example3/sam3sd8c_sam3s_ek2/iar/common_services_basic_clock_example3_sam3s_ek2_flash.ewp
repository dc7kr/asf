# IAR project common_services_basic_clock_example3_sam3s_ek2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM3SD8 Atmel SAM3SD8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  ICCARM.CCIncludePath2: ../../../../../../sam/drivers/uart; ../../../../../../sam/utils; ../../..; ../../../../../../sam/boards; ..; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../../sam/utils/cmsis/sam3s8/source/templates; ../../../../../../sam/drivers/pmc; ../../../../../../sam/drivers/pio; ../../../../../../sam/utils/cmsis/sam3s8/include; ../../../../../../sam/boards/sam3s_ek2; ../../../../gpio; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM3SD8C__; BOARD=SAM3S_EK2
  OBJCOPY.OOCOutputFile: Debug\Exe\output.bin
  ILINK.IlinkOutputFile: common_services_basic_clock_example3_sam3s_ek2_flash.elf
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam3s/sam3sd8/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: output.bin
  group sam/utils/cmsis/sam3s8/source/templates
    ../../../../../../sam/utils/cmsis/sam3s8/source/templates/: exceptions.c system_sam3sd8.c
  group sam/utils/cmsis/sam3s8/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam3s8/source/templates/iar/: startup_sam3sd8.c
  group sam/utils/syscalls/iar
    ../../../../../../sam/utils/syscalls/iar/: dlib_lowlevel.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio_handler.c pio.c
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam/boards/sam3s_ek2
    ../../../../../../sam/boards/sam3s_ek2/: init.c
  group common/services/clock/sam3s
    ../../../sam3s/: sysclk.c
  group common/services/clock/example3
    ../../: clock_example3_sam.c
