<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_gfx_mono_unit_test_menu_xmega_a1_xplain.ewp</path>
	</project>
</workspace>
