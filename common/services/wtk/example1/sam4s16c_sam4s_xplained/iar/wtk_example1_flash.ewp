# IAR project wtk_example1_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: SAM4S16C Atmel SAM4S16C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAM4S16C__; CONF_GFX_ILI9341_SDT028ATFT=1; ARM_MATH_CM4=true; BOARD=SAM4S_XPLAINED
  ICCARM.CCIncludePath2: ../../../../spi/sam_spi; ../../../../../../sam/utils/preprocessor; ../../../../../../sam/drivers/pmc; ../../../../../../sam/utils/cmsis/sam4s/include; ../../../../gfx; ../../../../twi; ../..; ../../../../../../sam/drivers/spi; ../../../../../utils; ../../../../../components/touch/mxt; ../../../../clock; ../../../../../../sam/boards; ../../..; ../../../../gpio; ../../../../../utils/membag; ..; ../../../../../../sam/utils/cmsis/sam4s/source/templates; ../../../../delay; ../../../../../../sam/utils; ../../../../spi; ../../../../../../sam/utils/header_files; ../../../../../boards; ../../../../../components/display_controller/ili9341; ../../../../ioport; ../../../../../../sam/drivers/pio; ../../../../../../sam/boards/sam4s_xplained; ../../../../../../sam/drivers/twi; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  OBJCOPY.OOCOutputFile: wtk_example1_flash.bin
  ILINK.IlinkOutputFile: wtk_example1_flash.out
  ILINK.IlinkIcfFile: ../../../../../../sam/utils/linker_scripts/sam4s/sam4s16/iar/flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/twi
    ../../../../../../sam/drivers/twi/: twi.c
  group sam/drivers/pio
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam/drivers/pmc
    ../../../../../../sam/drivers/pmc/: pmc.c
  group sam/utils/cmsis/sam4s/source/templates
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/: system_sam4s.c exceptions.c
  group sam/utils/cmsis/sam4s/source/templates/iar
    ../../../../../../sam/utils/cmsis/sam4s/source/templates/iar/: startup_sam4s.c
  group sam/boards/sam4s_xplained
    ../../../../../../sam/boards/sam4s_xplained/: init.c
  group common/services/wtk
    ../../../: win.c wtk.c wtk_basic_frame.c wtk_button.c wtk_radio_button.c wtk_progress_bar.c wtk_slider.c wtk_check_box.c wtk_label.c wtk_frame.c
  group common/services/wtk/example1
    ../../: example1.c widget_gui.c
  group common/services/clock/sam4s
    ../../../../clock/sam4s/: sysclk.c
  group common/services/gfx
    ../../../../gfx/: gfx_ili9341_sdt028atft.c sysfont.c gfx_generic.c gfx_text.c
  group common/services/delay/sam
    ../../../../delay/sam/: cycle_counter.c
  group common/services/spi/sam_spi
    ../../../../spi/sam_spi/: spi_master.c
  group common/components/touch/mxt
    ../../../../../components/touch/mxt/: mxt_device.c
  group common/components/display_controller/ili9341
    ../../../../../components/display_controller/ili9341/: ili9341.c
  group common/utils/membag
    ../../../../../utils/membag/: membag.c
  group common/utils/interrupt
    ../../../../../utils/interrupt/: interrupt_sam_nvic.c
