<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_services_basic_spi_master_example_sam3n_ek_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\common_services_basic_spi_master_example_sam3n_ek_sram.ewp</path>
	</project>
</workspace>
