# IAR project mxt143e_xplained_paint_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-6s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x1000
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: GFX_INITIALIZED=1; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  ICCAVR.CCDiagSuppress: Pa050
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/boards/xmega_a1_xplained; ../../../../services/delay; ../../../../../xmega/drivers/pmic; ../..; ../../../../services/gfx; ../../../../services/clock; ../../../../services/twi; ../../../../services/spi; ../../../../boards; ../../../../services/ioport; ../../../../../xmega/utils; ../../../../components/display_controller/ili9341; ..; ../../../../../xmega/drivers/usart; ../../../../../xmega/boards; ../../../../../xmega/utils/preprocessor; ../../../../utils; ../../../../services/gpio; ../../../../../xmega/drivers/cpu; ../../../../components/touch/mxt; ../../../../../xmega/drivers/twi; .
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  AAVR.ADefines: as above
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm128a1.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; GFX_INITIALIZED=1; CONF_GFX_ILI9341_SDT028ATFT=1; BOARD=XMEGA_A1_XPLAINED; IOPORT_XMEGA_COMPAT
  XLINK.XclFile: lnk0t.xcl
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_text.c gfx_ili9341_sdt028atft.c sysfont.c
  group common/services/clock/xmega
    ../../../../services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/spi/xmega_usart_spi
    ../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c
  group common/components/display_controller/ili9341
    ../../../../components/display_controller/ili9341/: ili9341.c
  group common/applications/mxt143e_xplained_paint_demo
    ../../: paint_demo.c
  group xmega/drivers/twi
    ../../../../../xmega/drivers/twi/: twis.c twim.c
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s
  group xmega/boards/xmega_a1_xplained
    ../../../../../xmega/boards/xmega_a1_xplained/: init.c
