<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\common_applications_led_chaser_stk600-xmega256a3u.ewp</path>
	</project>
</workspace>
