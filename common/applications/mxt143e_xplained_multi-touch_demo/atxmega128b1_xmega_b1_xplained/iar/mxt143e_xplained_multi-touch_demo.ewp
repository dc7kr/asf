# IAR project mxt143e_xplained_multi-touch_demo.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 0x100
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x1000
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: xm128b1 ATxmega128B1
  ICCAVR.CCDefines: BOARD=XMEGA_B1_XPLAINED; GFX_INITIALIZED=1; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  ICCAVR.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\; ../../../../../xmega/drivers/pmic; ../../../../../xmega/utils; ../../../../services/gfx; ../../../../services/gpio; ../../../../services/ioport; ../../../../../xmega/drivers/usart; ../../../../../xmega/drivers/nvm; ../../../../utils; ../../../../components/touch/mxt; ../../../../services/clock; ../../../../../xmega/boards/xmega_b1_xplained; ../../../../services/delay; ../../../../../xmega/boards; ../../../../services/twi; ../..; ..; ../../../../../xmega/drivers/twi; ../../../../services/spi; ../../../../boards; ../../../../components/display_controller/ili9341; ../../../../../xmega/utils/preprocessor; ../../../../../xmega/drivers/cpu; .
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 3
  AAVR.ADefines: as above
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG; BOARD=XMEGA_B1_XPLAINED; GFX_INITIALIZED=1; CONF_GFX_ILI9341_SDT028ATFT=1; IOPORT_XMEGA_COMPAT
  group common/services/gfx
    ../../../../services/gfx/: gfx_generic.c gfx_text.c gfx_ili9341_sdt028atft.c sysfont.c
  group common/services/clock/xmega
    ../../../../services/clock/xmega/: sysclk.c
  group common/services/ioport/xmega
    ../../../../services/ioport/xmega/: ioport_compat.c
  group common/services/spi/xmega_usart_spi
    ../../../../services/spi/xmega_usart_spi/: usart_spi.c
  group common/components/touch/mxt
    ../../../../components/touch/mxt/: mxt_device.c
  group common/components/display_controller/ili9341
    ../../../../components/display_controller/ili9341/: ili9341.c
  group common/applications/mxt143e_xplained_multi-touch_demo
    ../../: multi-touch_demo.c
  group xmega/boards/xmega_b1_xplained
    ../../../../../xmega/boards/xmega_b1_xplained/: init.c
  group xmega/drivers/twi
    ../../../../../xmega/drivers/twi/: twim.c twis.c
  group xmega/drivers/nvm
    ../../../../../xmega/drivers/nvm/: nvm.c nvm_asm.s
  group xmega/drivers/usart
    ../../../../../xmega/drivers/usart/: usart.c
  group xmega/drivers/cpu
    ../../../../../xmega/drivers/cpu/: ccp.s
