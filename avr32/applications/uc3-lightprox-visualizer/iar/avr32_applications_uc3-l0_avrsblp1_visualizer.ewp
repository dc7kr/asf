# IAR project avr32_applications_uc3-l0_avrsblp1_visualizer.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: EXT_BOARD=SENSORS_XPLAINED_LIGHTPROX_1; BOARD=UC3_L0_XPLAINED; SHARED_PIN_PA11_IS_INPUT; CONF_STDIO_REDIRECT
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../common/utils/stdio/stdio_serial; ../../../drivers/gpio; ../../../../common/services/delay; ../../../../common/services/clock; ../../../../common/services/sensors; ../../../../common/services/serial; ../../../../common/boards; ../../../drivers/usart; ../conf; ../../../../common/services; ../../../boards; ../../../utils; ../../../drivers/cpu/cycle_counter; ../../../drivers/flashcdw; ../../../utils/preprocessor; ../../../boards/uc3_l0_xplained; ../../../../common/utils; ../../../../common/services/sensors/module_config; ../../../drivers/intc; ../../../drivers/eic; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/sensors/libs/iar
    ../../../../thirdparty/sensors/libs/iar/: libsensors-at32uc3l-debug.r82
  group avr32/drivers/eic
    ../../../drivers/eic/: eic.c
  group avr32/drivers/flashcdw
    ../../../drivers/flashcdw/: flashcdw.c
  group avr32/drivers/intc
    ../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/gpio
    ../../../drivers/gpio/: gpio.c
  group avr32/drivers/usart
    ../../../drivers/usart/: usart.c
  group avr32/boards/uc3_l0_xplained
    ../../../boards/uc3_l0_xplained/: led.c init.c
  group avr32/utils/startup
    ../../../utils/startup/: trampoline_uc3.s82
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c
  group common/services/clock/uc3l
    ../../../../common/services/clock/uc3l/: sysclk.c dfll.c osc.c
  group common/services/sensors
    ../../../../common/services/sensors/: sensor_bus.c sensor_nvram.c sensor.c sensor_platform.c
  group common/services/sensors/drivers/platform/avr32
    ../../../../common/services/sensors/drivers/platform/avr32/: twim.c
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c
  group common/applications/sensors/lightprox_visualizer
    ../../../../common/applications/sensors/lightprox_visualizer/: data_visualizer.c main.c
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
