<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-a3_avrsblp1_visualizer.ewp</path>
	</project>
</workspace>
