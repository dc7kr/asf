# IAR project avr32_applications_uc3-a3_avrsblp1_visualizer.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: EXT_BOARD=SENSORS_XPLAINED_LIGHTPROX_1; UDD_ENABLE; BOARD=UC3_A3_XPLAINED; CONF_STDIO_REDIRECT
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../common/services/usb/class/cdc/device; ../../../../common/services/sensors; ../../../boards; ../../../drivers/usbb; ../../../drivers/pm; ../../../drivers/eic; ../../../../common/services; ../../../../common/utils/stdio/stdio_usb; ../../../utils; ../../../drivers/gpio; ../../../../common/services/sleepmgr; ../../../../common/utils; ../../../../common/services/usb/class/cdc; ../../../../common/services/clock; ../conf; ../../../../common/services/usb/udc; ../../../../common/services/usb; ../../../drivers/cpu/cycle_counter; ../../../boards/uc3_a3_xplained; ../../../../common/services/delay; ../../../../common/boards; ../../../drivers/flashc; ../../../utils/preprocessor; ../../../drivers/intc; ../../../../common/services/sensors/module_config; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../utils/linker_scripts/at32uc3a3/256/iar/lnkuc3a3256.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/sensors/libs/iar
    ../../../../thirdparty/sensors/libs/iar/: libsensors-at32uc3a3-debug.r82
  group avr32/drivers/eic
    ../../../drivers/eic/: eic.c
  group avr32/drivers/usbb
    ../../../drivers/usbb/: usbb_device.c
  group avr32/drivers/pm
    ../../../drivers/pm/: pm.c pm_conf_clocks.c power_clocks_lib.c
  group avr32/drivers/intc
    ../../../drivers/intc/: intc.c exception.s82
  group avr32/drivers/gpio
    ../../../drivers/gpio/: gpio.c
  group avr32/drivers/flashc
    ../../../drivers/flashc/: flashc.c
  group avr32/boards/uc3_a3_xplained
    ../../../boards/uc3_a3_xplained/: init.c led.c
  group avr32/utils/startup
    ../../../utils/startup/: trampoline_uc3.s82
  group common/services/usb/class/cdc/device
    ../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c
  group common/services/usb/udc
    ../../../../common/services/usb/udc/: udc.c
  group common/services/clock/uc3a3_a4
    ../../../../common/services/clock/uc3a3_a4/: sysclk.c
  group common/services/sensors
    ../../../../common/services/sensors/: sensor.c sensor_nvram.c sensor_platform.c sensor_bus.c
  group common/services/sensors/drivers/platform/avr32
    ../../../../common/services/sensors/drivers/platform/avr32/: twim.c
  group common/services/sensors/physics
    ../../../../common/services/sensors/physics/: physics.c
  group common/services/sleepmgr/uc3
    ../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/utils/stdio
    ../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_usb
    ../../../../common/utils/stdio/stdio_usb/: stdio_usb.c
  group common/applications/sensors/lightprox_visualizer
    ../../../../common/applications/sensors/lightprox_visualizer/: data_visualizer.c main.c
  group common/boards/sensors_xplained
    ../../../../common/boards/sensors_xplained/: sensors_xplained.c
