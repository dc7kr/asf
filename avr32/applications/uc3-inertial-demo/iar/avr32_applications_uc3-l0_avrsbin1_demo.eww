<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-l0_avrsbin1_demo.ewp</path>
	</project>
</workspace>
