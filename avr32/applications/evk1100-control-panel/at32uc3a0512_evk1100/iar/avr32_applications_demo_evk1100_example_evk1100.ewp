# IAR project avr32_applications_demo_evk1100_example_evk1100.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasf.h
  General.GSStackSize: 0x200
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x7154
  ICCAVR32.CCDefines: SMTP_USED=0; NW_INTEGRATED_IN_CONTROL_PANEL=1; USB_ENABLE=1; HTTP_USED=1; BOARD=EVK1100; FREERTOS_USED; ACCESS_MEM_TO_RAM_ENABLED; TFTP_USED=0; MMILCD_ENABLE=1; DISPLAY_MMI_SECOND=1; SD_MMC_SPI_ENABLE; AT45DBX_ENABLE
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder; ../../../../utils/debug; ../../../../drivers/usbb/_asf_v1/enum/device; ../../../../services/fs/fat; ../../../../components/display/dip204; ../../../../drivers/macb; ../../../../components/memory/sd_mmc/sd_mmc_spi; ../../../../drivers/ebi/sdramc; ../../../../components/joystick/skrhabe010; ../../../../boards; ../../usb/appli/enum/device; ../../network/smtpclient; ../../../../drivers/pm; ../../localctrl; ../../usb/appli; ../../../../drivers/flashc; ../../sensors; ../../../../services/usb/_asf_v1; ../../utils; ../../../../drivers/usbb/_asf_v1; ../../../../../thirdparty/lwip/lwip-1.3.2/src/include; ../../../../services/usb/_asf_v1/class/mass_storage/host_mem; ../../../../drivers/tc; ../../actuators; ../../shell; ../../../../components/ethernet_phy/rtl8201; ../../../../utils; ../../mmi; ../../../../boards/evk1100; ../..; ../../../../../common/utils; ../../../../components/memory/sdram; ../../../../drivers/spi; ../../../../../thirdparty/freertos/source/include; ../../usb/appli/enum; ../../../../drivers/gpio; ../../usb/appli/mass_storage; ../../../../../common/services/clock; ../../../../drivers/pwm; ../../serial; ../../../../../thirdparty/lwip/lwip-1.3.2/src/include/ipv4; ../../../../drivers/cpu/cycle_counter; ../../../../drivers/usbb/_asf_v1/enum; ../../../../drivers/usbb/_asf_v1/enum/host; ../../config; ../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3; ../../../../../common/services/delay; ../../../../components/ethernet_phy; ../../../../utils/preprocessor; ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1; ../../../../drivers/usart; ../../../../components/ethernet_phy/dp83848; ../../../../../common/boards; ../../../../../thirdparty/lwip/lwip-port-1.3.2/at32uc3/include; ../../network/webserver; ../../../../drivers/intc; ../../../../components/ethernet_phy/dummy_phy; ../../network/tftpserver; ../../network; ../../../../../common/services/storage/ctrl_access; ../../../../drivers/adc; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: as above
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../utils/linker_scripts/at32uc3a/0512/iar/lnkuc3a0512.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group thirdparty/lwip/lwip-1.3.2/src/core
    ../../../../../thirdparty/lwip/lwip-1.3.2/src/core/: tcp.c memp.c tcp_in.c mem.c dns.c dhcp.c sys.c init.c raw.c stats.c netif.c tcp_out.c pbuf.c udp.c
  group thirdparty/lwip/lwip-1.3.2/src/core/ipv4
    ../../../../../thirdparty/lwip/lwip-1.3.2/src/core/ipv4/: ip.c autoip.c ip_addr.c igmp.c icmp.c ip_frag.c inet.c inet_chksum.c
  group thirdparty/lwip/lwip-1.3.2/src/api
    ../../../../../thirdparty/lwip/lwip-1.3.2/src/api/: sockets.c netdb.c err.c tcpip.c netbuf.c netifapi.c api_lib.c api_msg.c
  group thirdparty/lwip/lwip-1.3.2/src/netif
    ../../../../../thirdparty/lwip/lwip-1.3.2/src/netif/: etharp.c
  group thirdparty/lwip/lwip-port-1.3.2/at32uc3
    ../../../../../thirdparty/lwip/lwip-port-1.3.2/at32uc3/: sys_arch.c
  group thirdparty/lwip/lwip-port-1.3.2/at32uc3/netif
    ../../../../../thirdparty/lwip/lwip-port-1.3.2/at32uc3/netif/: ethernetif.c
  group thirdparty/freertos/source
    ../../../../../thirdparty/freertos/source/: queue.c croutine.c list.c tasks.c timers.c
  group thirdparty/freertos/source/portable/memmang
    ../../../../../thirdparty/freertos/source/portable/memmang/: heap_3.c
  group thirdparty/freertos/source/portable/iar/avr32_uc3
    ../../../../../thirdparty/freertos/source/portable/iar/avr32_uc3/: write.c read.c port.c exception.s82
  group avr32/applications/evk1100-control-panel
    ../../: main.c
  group avr32/applications/evk1100-control-panel/serial
    ../../serial/: serial.c
  group avr32/applications/evk1100-control-panel/usb/appli
    ../../usb/appli/: usbsys.c
  group avr32/applications/evk1100-control-panel/usb/appli/enum/device
    ../../usb/appli/enum/device/: usb_specific_request.c usb_descriptors.c
  group avr32/applications/evk1100-control-panel/usb/appli/mass_storage
    ../../usb/appli/mass_storage/: device_mass_storage_task.c host_mass_storage_task.c
  group avr32/applications/evk1100-control-panel/sensors
    ../../sensors/: pushb.c light.c sensor.c potentiometer.c joystick.c temperature.c
  group avr32/applications/evk1100-control-panel/actuators
    ../../actuators/: actuator.c lcd.c cpled.c
  group avr32/applications/evk1100-control-panel/utils
    ../../utils/: printf-stdarg.c tracedump.c
  group avr32/applications/evk1100-control-panel/shell
    ../../shell/: fscmds.c com1shell.c shell.c
  group avr32/applications/evk1100-control-panel/network
    ../../network/: ethernet.c
  group avr32/applications/evk1100-control-panel/network/tftpserver
    ../../network/tftpserver/: BasicTFTP.c
  group avr32/applications/evk1100-control-panel/network/webserver
    ../../network/webserver/: BasicWEB.c
  group avr32/applications/evk1100-control-panel/network/smtpclient
    ../../network/smtpclient/: BasicSMTP.c
  group avr32/applications/evk1100-control-panel/config
    ../../config/: config_file.c
  group avr32/applications/evk1100-control-panel/localctrl
    ../../localctrl/: supervisor.c syscmds.c datalog.c cptime.c
  group avr32/applications/evk1100-control-panel/mmi
    ../../mmi/: mmi.c
  group avr32/services/fs/fat
    ../../../../services/fs/fat/: navigation.c fsaccess.c file.c fat_unusual.c fat.c
  group avr32/services/usb/_asf_v1/class/mass_storage/host_mem
    ../../../../services/usb/_asf_v1/class/mass_storage/host_mem/: host_mem.c
  group avr32/services/usb/_asf_v1/class/mass_storage/scsi_decoder
    ../../../../services/usb/_asf_v1/class/mass_storage/scsi_decoder/: scsi_decoder.c
  group avr32/components/display/dip204
    ../../../../components/display/dip204/: dip204.c
  group avr32/components/memory/sd_mmc/sd_mmc_spi
    ../../../../components/memory/sd_mmc/sd_mmc_spi/: sd_mmc_spi_mem.c sd_mmc_spi.c
  group avr32/utils/debug
    ../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../utils/startup/: trampoline_uc3.s82
  group avr32/drivers/usbb/_asf_v1
    ../../../../drivers/usbb/_asf_v1/: usb_drv.c
  group avr32/drivers/usbb/_asf_v1/enum
    ../../../../drivers/usbb/_asf_v1/enum/: usb_task.c
  group avr32/drivers/usbb/_asf_v1/enum/device
    ../../../../drivers/usbb/_asf_v1/enum/device/: usb_device_task.c usb_standard_request.c
  group avr32/drivers/usbb/_asf_v1/enum/host
    ../../../../drivers/usbb/_asf_v1/enum/host/: usb_host_enum.c usb_host_task.c
  group avr32/drivers/ebi/sdramc
    ../../../../drivers/ebi/sdramc/: sdramc.c
  group avr32/drivers/usart
    ../../../../drivers/usart/: usart.c
  group avr32/drivers/pm
    ../../../../drivers/pm/: pm_conf_clocks.c power_clocks_lib.c pm.c
  group avr32/drivers/tc
    ../../../../drivers/tc/: tc.c
  group avr32/drivers/adc
    ../../../../drivers/adc/: adc.c
  group avr32/drivers/macb
    ../../../../drivers/macb/: macb.c
  group avr32/drivers/gpio
    ../../../../drivers/gpio/: gpio.c
  group avr32/drivers/pwm
    ../../../../drivers/pwm/: pwm.c
  group avr32/drivers/flashc
    ../../../../drivers/flashc/: flashc.c
  group avr32/drivers/intc
    ../../../../drivers/intc/: intc.c
  group avr32/drivers/spi
    ../../../../drivers/spi/: spi.c
  group avr32/boards/evk1100
    ../../../../boards/evk1100/: led.c
  group common/services/clock/uc3a0_a1
    ../../../../../common/services/clock/uc3a0_a1/: sysclk.c
  group common/services/storage/ctrl_access
    ../../../../../common/services/storage/ctrl_access/: ctrl_access.c
  group common/components/memory/data_flash/at45dbx/_asf_v1
    ../../../../../common/components/memory/data_flash/at45dbx/_asf_v1/: at45dbx_mem.c at45dbx.c
