<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_rz600-uc3a-wireless-uart-at86rf231.ewp</path>
	</project>
</workspace>
