<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_audio-player_wav_evk1104.ewp</path>
	</project>
</workspace>
