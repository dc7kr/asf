<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_applications_uc3-a3_avrsbpr1_demo.ewp</path>
	</project>
</workspace>
