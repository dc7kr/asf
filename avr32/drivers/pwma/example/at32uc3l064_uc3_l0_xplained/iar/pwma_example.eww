<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\pwma_example.ewp</path>
	</project>
</workspace>
