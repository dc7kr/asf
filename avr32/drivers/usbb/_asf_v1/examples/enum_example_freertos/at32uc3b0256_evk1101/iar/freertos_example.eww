<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\freertos_example.ewp</path>
	</project>
</workspace>
