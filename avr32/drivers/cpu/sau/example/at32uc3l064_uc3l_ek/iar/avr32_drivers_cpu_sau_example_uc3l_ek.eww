<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\avr32_drivers_cpu_sau_example_uc3l_ek.ewp</path>
	</project>
</workspace>
