# IAR project adcifb_example2.ewp, settings and files
configuration Debug (AVR32, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlavr32bllasn.h
  General.GSStackSize: 0x1000
  General.GCStackSize: 0x0000
  General.GHeapSize: 0x1000
  ICCAVR32.CCDefines: BOARD=UC3_L0_XPLAINED
  ICCAVR32.CCDiagSuppress: Pa050
  ICCAVR32.CCIncludePath2: ../../../../../boards/uc3_l0_xplained; ../../../../../utils/preprocessor; ../../../../ast; ../../../../../../common/services/clock; ../../../../../utils/debug; ..; ../../../../../../common/boards; ../../../../../boards; ../../../../usart; ../../../../scif; ../../../../pm; ../../../../../utils; ../../../../cpu/cycle_counter; ../../../../../services/delay; ../../../../gpio; ../../../../flashcdw; ../../../../../../common/services/sleepmgr; ../../../../../../common/utils; ../../..; .
  ICCAVR32.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCAVR32.CCOptLevel: 3
  ICCAVR32.CCOptStrategy: 1
  AAVR32.ADefines: BOARD=UC3_L0_XPLAINED
  AAVR32.AIncludePaths: as above
  AAVR32.AStandardIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: ../../../../../utils/linker_scripts/at32uc3l/064/iar/lnkuc3l064.xcl
configuration Release (AVR32)
  as the first configuration, except:
  group avr32/drivers/adcifb
    ../../../: adcifb.c
  group avr32/drivers/adcifb/example2
    ../../: adcifb_sleepwalking_example.c
  group avr32/drivers/gpio
    ../../../../gpio/: gpio.c
  group avr32/drivers/flashcdw
    ../../../../flashcdw/: flashcdw.c
  group avr32/drivers/pm
    ../../../../pm/: pm_uc3l.c power_clocks_lib.c
  group avr32/drivers/usart
    ../../../../usart/: usart.c
  group avr32/drivers/scif
    ../../../../scif/: scif_uc3l.c
  group avr32/drivers/ast
    ../../../../ast/: ast.c
  group avr32/boards/uc3_l0_xplained
    ../../../../../boards/uc3_l0_xplained/: led.c
  group avr32/utils/debug
    ../../../../../utils/debug/: print_funcs.c
  group avr32/utils/startup
    ../../../../../utils/startup/: trampoline_uc3.s82
  group avr32/services/delay
    ../../../../../services/delay/: delay.c
  group common/services/sleepmgr/uc3
    ../../../../../../common/services/sleepmgr/uc3/: sleepmgr.c
  group common/services/clock/uc3l
    ../../../../../../common/services/clock/uc3l/: dfll.c sysclk.c osc.c
